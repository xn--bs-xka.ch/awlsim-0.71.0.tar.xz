//
//
// GENERATED by generate_benchmark.py
//
// iterations=10000
// seed=42
//
//

ORGANIZATION_BLOCK OB 1
BEGIN
	<>I;
	U TRUE;
	FR Z 42;
	TAD;
	>D;
	FP M 0.4;
	XOD;
	SET;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	TAN;
	O FALSE;
	CLR;
	NEGR;
	TRUNC;
	L 0;
	SI T 42;
	CC FC 43;
	U FALSE;
	XOD;
	COS;
	TAW;
	T MD 0;
	NOP 0;
	L 0;
	CLR;
	SPB AAAA;
AAAA:	NOP 0;
	UN M 0.4;
	<>R;
	TAN;
	+I;
	L 0;
	CLR;
	SPB AAAB;
AAAB:	NOP 0;
	==R;
	NEGR;
	L 0;
	CLR;
	LOOP AAAC;
AAAC:	NOP 0;
	FP M 0.4;
	CLR;
	+R;
	SAVE;
	+ 0;
	-I;
	CC FC 43;
	AUF DB 42;
	XN TRUE;
	UD;
	>=I;
	MOD;
	S M 0.4;
	PUSH;
	L 0;
	CLR;
	SPBI AAAD;
AAAD:	NOP 0;
	+D;
	+AR1;
	DTB;
	XN(;
	);
	XN FALSE;
	L 0;
	CLR;
	SPBNB AAAE;
AAAE:	NOP 0;
	S M 0.4;
	TRUNC;
	FN M 0.4;
	+R;
	L 0;
	CLR;
	SPB AAAF;
AAAF:	NOP 0;
	TAR1;
	-D;
	>R;
	*D;
	/I;
	NEGI;
	TDB;
	= M 0.4;
	UC FC 44;
	>=R;
	XOW;
	FR Z 42;
	>R;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	+R;
	L 0;
	CLR;
	SPA AAAG;
AAAG:	NOP 0;
	POP;
	TAW;
	L 0;
	CLR;
	SPPZ AAAH;
AAAH:	NOP 0;
	O(;
	);
	RND;
	O TRUE;
	SQR;
	TDB;
	X(;
	);
	NEGD;
	INC 0;
	L 0;
	CLR;
	SPN AAAI;
AAAI:	NOP 0;
	NEGD;
	RLDA;
	ABS;
	TAR2;
	<D;
	AUF DB 42;
	>D;
	L DW#16#89FA6A68;
	BLD 0;
	ASIN;
	BLD 0;
	SQR;
	+D;
	TAW;
	>D;
	L 0;
	SV T 42;
	RRD;
	CLR;
	U(;
	);
	<>I;
	==R;
	<>R;
	TAN;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	X(;
	);
	-R;
	+R;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	SSI;
	OW;
	LC MW 0;
	PUSH;
	O M 0.4;
	>I;
	UD;
	TDB;
	+I;
	<>I;
	L 0;
	CLR;
	SPBI AAAJ;
AAAJ:	NOP 0;
	ATAN;
	<>R;
	TAR1;
	U M 0.4;
	AUF DB 42;
	RRDA;
	L 0;
	BTI;
	L 0;
	SI T 42;
	==I;
	L 0;
	CLR;
	SPBIN AAAK;
AAAK:	NOP 0;
	L 0;
	SI T 42;
	UC FC 44;
	DTR;
	==R;
	/D;
	>R;
	OD;
	OW;
	U M 0.4;
	SET;
	L 0;
	CLR;
	SPM AAAL;
AAAL:	NOP 0;
	RLD;
	X M 0.4;
	<>I;
	+D;
	L 0;
	CLR;
	SPS AAAM;
AAAM:	NOP 0;
	RND-;
	O(;
	);
	RND-;
	INC 0;
	S M 0.4;
	NOT;
	SRD;
	XN(;
	);
	XOW;
	<=I;
	<=I;
	SLW;
	TAK;
	<R;
	AUF DB 42;
	OW;
	UC FC 44;
	TAN;
	NEGD;
	OD;
	INVI;
	L 0;
	CLR;
	SPZ AAAN;
AAAN:	NOP 0;
	SQR;
	/D;
	LAR1;
	L 0;
	SS T 42;
	TAR;
	<I;
	L DW#16#3985C3CF;
	L 0;
	CLR;
	LOOP AAAO;
AAAO:	NOP 0;
	XN M 0.4;
	NOP 0;
	PUSH;
	RND;
	NOP 0;
	TAW;
	UN M 0.4;
	= M 0.4;
	ON(;
	);
	RND;
	XN(;
	);
	O TRUE;
	= M 0.4;
	L 0;
	SE T 42;
	RND+;
	L 0;
	CLR;
	SPB AAAP;
AAAP:	NOP 0;
	SRD;
	NEGD;
	OD;
	==D;
	DEC 0;
	+AR1;
	SLW;
	FR Z 42;
	SLW;
	EXP;
	ITD;
	SAVE;
	SAVE;
	ACOS;
	/I;
	TAN;
	LN;
	SSI;
	UN(;
	);
	FN M 0.4;
	ON(;
	);
	SQRT;
	L 0;
	CLR;
	LOOP AAAQ;
AAAQ:	NOP 0;
	==I;
	L DW#16#310C0C00;
	UD;
	T MD 0;
	>D;
	TAN;
	ITB;
	L 0;
	CLR;
	SPB AAAR;
AAAR:	NOP 0;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	L DW#16#134C6C92;
	TAK;
	FN M 0.4;
	U(;
	);
	OD;
	ON M 0.4;
	CLR;
	RND+;
	<R;
	EXP;
	SRD;
	SLD;
	NEGD;
	SQR;
	ON(;
	);
	<R;
	+R;
	U M 0.4;
	*R;
	AUF DB 42;
	TAR1;
	L 0;
	CLR;
	SPBB AAAS;
AAAS:	NOP 0;
	TAN;
	POP;
	SRD;
	==R;
	ITD;
	L 0;
	CLR;
	SPBI AAAT;
AAAT:	NOP 0;
	NEGR;
	O(;
	);
	+AR2;
	OD;
	ON(;
	);
	L 0;
	CLR;
	SPN AAAU;
AAAU:	NOP 0;
	O(;
	);
	U(;
	);
	BLD 0;
	SRW;
	RRDA;
	OW;
	<>R;
	O(;
	);
	L 0;
	SV T 42;
	S M 0.4;
	L 0;
	BTD;
	XN(;
	);
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	XN(;
	);
	RND+;
	SQRT;
	<I;
	INC 0;
	L DW#16#14FCDD54;
	BLD 0;
	LEAVE;
	L 0;
	SA T 42;
	L 0;
	CLR;
	SPN AAAV;
AAAV:	NOP 0;
	ZR Z 42;
	INVD;
	L 0;
	CLR;
	SPN AAAW;
AAAW:	NOP 0;
	RND-;
	AUF DB 42;
	ABS;
	==D;
	L 0;
	CLR;
	SPBIN AAAX;
AAAX:	NOP 0;
	TAR2;
	L 0;
	CLR;
	SPN AAAY;
AAAY:	NOP 0;
	= M 0.4;
	O M 0.4;
	TAR2;
	LEAVE;
	FN M 0.4;
	= M 0.4;
	UD;
	NEGD;
	L 0;
	SI T 42;
	AUF DB 42;
	==D;
	*I;
	XN(;
	);
	FR Z 42;
	*D;
	L 0;
	CLR;
	SPBN AAAZ;
AAAZ:	NOP 0;
	<>R;
	LAR1;
	XOD;
	L 0;
	CLR;
	SPO AABA;
AABA:	NOP 0;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	OW;
	O M 0.4;
	PUSH;
	L 0;
	CLR;
	SPBIN AABB;
AABB:	NOP 0;
	FP M 0.4;
	<>D;
	AUF DB 42;
	>I;
	==I;
	PUSH;
	==R;
	L 0;
	CLR;
	SPA AABC;
AABC:	NOP 0;
	L 0;
	CLR;
	SPBN AABD;
AABD:	NOP 0;
	CC FC 43;
	NEGI;
	+I;
	INVD;
	AUF DB 42;
	L 0;
	SI T 42;
	RLD;
	LC MW 0;
	UN(;
	);
	CLR;
	TAN;
	L 0;
	L 0;
	CLR;
	SPL AABE;
AABE:	NOP 0;
	XN FALSE;
	L 0;
	CLR;
	SPU AABF;
AABF:	NOP 0;
	==D;
	AUF DB 42;
	>R;
	LAR2;
	PUSH;
	ASIN;
	ENT;
	O M 0.4;
	<>I;
	R M 0.4;
	<=D;
	XOD;
	ON TRUE;
	BLD 0;
	PUSH;
	>=D;
	ACOS;
	<=I;
	X TRUE;
	-D;
	X TRUE;
	NEGI;
	L DW#16#AABC25FA;
	/I;
	ENT;
	EXP;
	==R;
	RND+;
	>R;
	L 0;
	BTI;
	LN;
	U FALSE;
	L 0;
	CLR;
	SPU AABG;
AABG:	NOP 0;
	LN;
	L DW#16#444D610B;
	==I;
	+R;
	ON TRUE;
	TAW;
	INVI;
	TAR2;
	*I;
	L 0;
	CLR;
	SPS AABH;
AABH:	NOP 0;
	RND;
	TAD;
	U FALSE;
	SQR;
	L 0;
	CLR;
	SPMZ AABI;
AABI:	NOP 0;
	L 0;
	CLR;
	SPB AABJ;
AABJ:	NOP 0;
	XN(;
	);
	L 0;
	CLR;
	SPB AABK;
AABK:	NOP 0;
	*I;
	L 0;
	SV T 42;
	SQR;
	UD;
	L 0;
	CLR;
	SPMZ AABL;
AABL:	NOP 0;
	UN FALSE;
	ZR Z 42;
	L 0;
	BTI;
	+AR2;
	AUF DB 42;
	ON FALSE;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	ATAN;
	-I;
	L 0;
	CLR;
	SPN AABM;
AABM:	NOP 0;
	ATAN;
	UC FC 44;
	L 0;
	SV T 42;
	>I;
	-R;
	+AR1;
	ITD;
	ZV Z 42;
	XN TRUE;
	U M 0.4;
	L 0;
	SA T 42;
	UD;
	DTR;
	-D;
	ACOS;
	XN(;
	);
	L 0;
	CLR;
	SPMZ AABN;
AABN:	NOP 0;
	L 0;
	CLR;
	SPN AABO;
AABO:	NOP 0;
	>=I;
	L 0;
	CLR;
	SPBIN AABP;
AABP:	NOP 0;
	L 0;
	SI T 42;
	L 0;
	CLR;
	SPZ AABQ;
AABQ:	NOP 0;
	EXP;
	L 0;
	CLR;
	SPPZ AABR;
AABR:	NOP 0;
	SQRT;
	L 0;
	CLR;
	SPBI AABS;
AABS:	NOP 0;
	PUSH;
	<=I;
	DTB;
	COS;
	+R;
	<=R;
	INC 0;
	L 0;
	CLR;
	SPO AABT;
AABT:	NOP 0;
	SQRT;
	TAK;
	U M 0.4;
	L 0;
	CLR;
	SPO AABU;
AABU:	NOP 0;
	L 0;
	CLR;
	SPBB AABV;
AABV:	NOP 0;
	NEGI;
	ACOS;
	+AR2;
	UC FC 44;
	L 0;
	CLR;
	SPM AABW;
AABW:	NOP 0;
	SSI;
	LAR2;
	LAR2;
	NEGD;
	L 0;
	SV T 42;
	SLW;
	>=R;
	NOT;
	L 0;
	CLR;
	SPBN AABX;
AABX:	NOP 0;
	L 0;
	SE T 42;
	L 0;
	CLR;
	SPU AABY;
AABY:	NOP 0;
	CLR;
	RND+;
	L 0;
	CLR;
	SPZ AABZ;
AABZ:	NOP 0;
	TAD;
	DTR;
	>=D;
	U FALSE;
	FR Z 42;
	SLW;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	= M 0.4;
	TAR1;
	SIN;
	+AR1;
	DTB;
	-R;
	RRD;
	SQR;
	FR Z 42;
	>=D;
	UN M 0.4;
	==I;
	TAN;
	TAW;
	L 0;
	BTI;
	L 0;
	SS T 42;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	U(;
	);
	POP;
	L DW#16#1F115B76;
	<>D;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	OW;
	ENT;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	L 0;
	CLR;
	SPP AACA;
AACA:	NOP 0;
	LAR2;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	L 0;
	SI T 42;
	ASIN;
	TAK;
	T MD 0;
	<>R;
	SLW;
	TAR;
	ZR Z 42;
	L DW#16#3D3F3799;
	LAR1;
	R M 0.4;
	L 0;
	CLR;
	SPBB AACB;
AACB:	NOP 0;
	RND+;
	L 0;
	CLR;
	SPA AACC;
AACC:	NOP 0;
	L 0;
	CLR;
	SPU AACD;
AACD:	NOP 0;
	L 0;
	CLR;
	SPP AACE;
AACE:	NOP 0;
	OD;
	S M 0.4;
	>D;
	<=D;
	TRUNC;
	-R;
	==R;
	NEGD;
	X(;
	);
	SIN;
	EXP;
	L 0;
	CLR;
	SPMZ AACF;
AACF:	NOP 0;
	OD;
	SSI;
	SIN;
	ON(;
	);
	INVD;
	COS;
	*R;
	BLD 0;
	XN M 0.4;
	+AR1;
	+R;
	SRW;
	UN M 0.4;
	/I;
	L 0;
	CLR;
	SPBIN AACG;
AACG:	NOP 0;
	*R;
	COS;
	UD;
	XOD;
	CC FC 43;
	TAW;
	SRD;
	TAW;
	L 0;
	CLR;
	SPA AACH;
AACH:	NOP 0;
	ATAN;
	SRD;
	UN TRUE;
	L 0;
	CLR;
	LOOP AACI;
AACI:	NOP 0;
	SQRT;
	<R;
	SSI;
	<=I;
	XOW;
	U TRUE;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	LEAVE;
	U FALSE;
	ASIN;
	<>D;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	ITB;
	U(;
	);
	ZR Z 42;
	+R;
	L 0;
	CLR;
	SPPZ AACJ;
AACJ:	NOP 0;
	NEGD;
	TAR1;
	L 0;
	CLR;
	SPPZ AACK;
AACK:	NOP 0;
	L 0;
	CLR;
	LOOP AACL;
AACL:	NOP 0;
	+R;
	L 0;
	CLR;
	SPB AACM;
AACM:	NOP 0;
	COS;
	LC MW 0;
	S M 0.4;
	SSD;
	X M 0.4;
	OD;
	UN(;
	);
	*I;
	TAD;
	XN(;
	);
	X FALSE;
	L DW#16#2702878B;
	<=I;
	SLW;
	>I;
	LEAVE;
	NEGR;
	SSI;
	ZV Z 42;
	*D;
	<R;
	UC FC 44;
	UC FC 44;
	>I;
	>R;
	L 0;
	CLR;
	SPZ AACN;
AACN:	NOP 0;
	==I;
	+AR2;
	U TRUE;
	+AR1;
	MOD;
	ABS;
	DTR;
	R M 0.4;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	FR Z 42;
	FP M 0.4;
	L 0;
	CLR;
	SPO AACO;
AACO:	NOP 0;
	SET;
	<I;
	LEAVE;
	X TRUE;
	XOW;
	ASIN;
	*D;
	XN(;
	);
	L 0;
	SI T 42;
	+I;
	ON M 0.4;
	COS;
	RLD;
	==I;
	ACOS;
	+D;
	TAR2;
	==R;
	ATAN;
	L 0;
	BTI;
	L 0;
	SA T 42;
	L 0;
	CLR;
	SPA AACP;
AACP:	NOP 0;
	UD;
	SLD;
	SSI;
	ATAN;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	TDB;
	L 0;
	CLR;
	SPM AACQ;
AACQ:	NOP 0;
	FR Z 42;
	SET;
	L 0;
	CLR;
	SPB AACR;
AACR:	NOP 0;
	TAR;
	FR Z 42;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	INC 0;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	+R;
	L 0;
	CLR;
	LOOP AACS;
AACS:	NOP 0;
	UN TRUE;
	L 0;
	CLR;
	SPPZ AACT;
AACT:	NOP 0;
	ITB;
	SRD;
	NEGD;
	/I;
	ZR Z 42;
	+I;
	L 0;
	CLR;
	SPB AACU;
AACU:	NOP 0;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	L 0;
	L 0;
	CLR;
	SPL AACV;
AACV:	NOP 0;
	POP;
	O M 0.4;
	L 0;
	SS T 42;
	ITD;
	NOT;
	RND-;
	EXP;
	RLD;
	POP;
	RND-;
	SLW;
	RLD;
	T MD 0;
	X M 0.4;
	CLR;
	L 0;
	CLR;
	SPBI AACW;
AACW:	NOP 0;
	TAW;
	SQRT;
	FR Z 42;
	L 0;
	CLR;
	SPS AACX;
AACX:	NOP 0;
	+AR2;
	*D;
	SLW;
	PUSH;
	OW;
	-I;
	TAN;
	TAK;
	L 0;
	CLR;
	SPMZ AACY;
AACY:	NOP 0;
	/I;
	TAR1;
	L 0;
	CLR;
	SPA AACZ;
AACZ:	NOP 0;
	L 0;
	CLR;
	SPS AADA;
AADA:	NOP 0;
	LC MW 0;
	TRUNC;
	<I;
	DTB;
	L 0;
	CLR;
	SPN AADB;
AADB:	NOP 0;
	<I;
	UD;
	L 0;
	BTD;
	DTB;
	NEGR;
	SLD;
	L 0;
	L 0;
	CLR;
	SPL AADC;
AADC:	NOP 0;
	NOP 0;
	UW;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	L 0;
	CLR;
	SPBN AADD;
AADD:	NOP 0;
	FN M 0.4;
	DTB;
	L 0;
	CLR;
	SPBI AADE;
AADE:	NOP 0;
	RND;
	+D;
	L 0;
	BTI;
	L 0;
	CLR;
	SPO AADF;
AADF:	NOP 0;
	ON M 0.4;
	XOW;
	<=I;
	L 0;
	L 0;
	CLR;
	SPL AADG;
AADG:	NOP 0;
	XN FALSE;
	PUSH;
	L 0;
	CLR;
	SPBNB AADH;
AADH:	NOP 0;
	<=I;
	RLD;
	FP M 0.4;
	ON M 0.4;
	DEC 0;
	L 0;
	CLR;
	SPBN AADI;
AADI:	NOP 0;
	SSD;
	SRW;
	LAR1;
	+I;
	L 0;
	BTD;
	UN(;
	);
	LC MW 0;
	SRW;
	>I;
	X(;
	);
	SQR;
	RLD;
	= M 0.4;
	+AR1;
	UN(;
	);
	<=D;
	<=D;
	LEAVE;
	L 0;
	CLR;
	SPO AADJ;
AADJ:	NOP 0;
	NOT;
	L DW#16#C3B290D0;
	UC FC 44;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	TAD;
	L 0;
	SA T 42;
	+R;
	TAR;
	LAR2;
	L 0;
	CLR;
	SPBIN AADK;
AADK:	NOP 0;
	NOP 0;
	ASIN;
	L 0;
	CLR;
	SPS AADL;
AADL:	NOP 0;
	INC 0;
	ON(;
	);
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	FN M 0.4;
	NEGI;
	NEGD;
	AUF DB 42;
	S M 0.4;
	<>R;
	RND-;
	<=R;
	PUSH;
	R M 0.4;
	<>R;
	U M 0.4;
	EXP;
	TAR;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	SSD;
	L 0;
	CLR;
	SPBNB AADM;
AADM:	NOP 0;
	O FALSE;
	L 0;
	CLR;
	SPBB AADN;
AADN:	NOP 0;
	L 0;
	CLR;
	SPBN AADO;
AADO:	NOP 0;
	TAR1;
	= M 0.4;
	TRUNC;
	AUF DB 42;
	NOP 0;
	DTR;
	TAN;
	>I;
	XOD;
	TAD;
	<=D;
	TDB;
	<D;
	= M 0.4;
	ON(;
	);
	<R;
	L 0;
	CLR;
	SPS AADP;
AADP:	NOP 0;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	INC 0;
	L 0;
	CLR;
	SPBB AADQ;
AADQ:	NOP 0;
	LAR1;
	>=I;
	SSI;
	L 0;
	CLR;
	SPO AADR;
AADR:	NOP 0;
	SQRT;
	L 0;
	CLR;
	SPA AADS;
AADS:	NOP 0;
	RRDA;
	OD;
	RRD;
	LAR1;
	S M 0.4;
	SET;
	X TRUE;
	L 0;
	CLR;
	SPM AADT;
AADT:	NOP 0;
	CC FC 43;
	LC MW 0;
	U FALSE;
	RND;
	+AR1;
	NOP 0;
	XN M 0.4;
	TDB;
	+AR1;
	X FALSE;
	SSD;
	L 0;
	SS T 42;
	LAR2;
	L 0;
	CLR;
	SPB AADU;
AADU:	NOP 0;
	ITB;
	BLD 0;
	ATAN;
	RLD;
	CLR;
	SSD;
	*I;
	EXP;
	L 0;
	CLR;
	SPU AADV;
AADV:	NOP 0;
	L 0;
	CLR;
	SPM AADW;
AADW:	NOP 0;
	FP M 0.4;
	>R;
	L 0;
	CLR;
	SPMZ AADX;
AADX:	NOP 0;
	LN;
	RRD;
	L 0;
	CLR;
	SPBB AADY;
AADY:	NOP 0;
	SQR;
	TAK;
	ON TRUE;
	SET;
	L 0;
	CLR;
	SPN AADZ;
AADZ:	NOP 0;
	LC MW 0;
	L 0;
	CLR;
	SPM AAEA;
AAEA:	NOP 0;
	>I;
	SQRT;
	L 0;
	SE T 42;
	U M 0.4;
	OD;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	LN;
	UN(;
	);
	ITD;
	L 0;
	SS T 42;
	+D;
	RLDA;
	LAR2;
	UN(;
	);
	INVD;
	TDB;
	TAK;
	==D;
	L 0;
	CLR;
	SPBB AAEB;
AAEB:	NOP 0;
	LAR1;
	SRD;
	>=I;
	UN FALSE;
	<>R;
	L 0;
	CLR;
	SPZ AAEC;
AAEC:	NOP 0;
	PUSH;
	ON M 0.4;
	PUSH;
	EXP;
	CLR;
	TAD;
	>I;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	<I;
	==R;
	RLDA;
	L 0;
	CLR;
	SPBNB AAED;
AAED:	NOP 0;
	L 0;
	SV T 42;
	L 0;
	CLR;
	SPA AAEE;
AAEE:	NOP 0;
	SIN;
	SLD;
	SSD;
	FR Z 42;
	TAR1;
	PUSH;
	>=D;
	-R;
	ITD;
	SET;
	L 0;
	SV T 42;
	<>D;
	XN(;
	);
	L 0;
	L 0;
	CLR;
	SPL AAEF;
AAEF:	NOP 0;
	SIN;
	+I;
	L 0;
	SI T 42;
	TDB;
	U M 0.4;
	L 0;
	CLR;
	SPBN AAEG;
AAEG:	NOP 0;
	L 0;
	CLR;
	SPBIN AAEH;
AAEH:	NOP 0;
	NOP 0;
	+AR2;
	RLD;
	<=D;
	T MD 0;
	UD;
	SLD;
	-I;
	L 0;
	CLR;
	SPU AAEI;
AAEI:	NOP 0;
	PUSH;
	XOD;
	MOD;
	TAR1;
	L 0;
	CLR;
	SPM AAEJ;
AAEJ:	NOP 0;
	ITD;
	RND-;
	DEC 0;
	-R;
	TRUNC;
	LN;
	XN TRUE;
	SLW;
	+R;
	-R;
	<=D;
	RRD;
	ON FALSE;
	RRDA;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	L 0;
	CLR;
	SPMZ AAEK;
AAEK:	NOP 0;
	FN M 0.4;
	LAR1;
	FN M 0.4;
	UW;
	TAR1;
	ON M 0.4;
	<D;
	EXP;
	==R;
	R M 0.4;
	SSD;
	AUF DB 42;
	L 0;
	CLR;
	LOOP AAEL;
AAEL:	NOP 0;
	ABS;
	S M 0.4;
	L 0;
	CLR;
	SPMZ AAEM;
AAEM:	NOP 0;
	XOW;
	+R;
	L 0;
	CLR;
	SPP AAEN;
AAEN:	NOP 0;
	SRD;
	OD;
	ON FALSE;
	RND+;
	L 0;
	CLR;
	SPBB AAEO;
AAEO:	NOP 0;
	RND;
	CLR;
	ATAN;
	FN M 0.4;
	FN M 0.4;
	LAR2;
	<R;
	L 0;
	CLR;
	SPBIN AAEP;
AAEP:	NOP 0;
	UN FALSE;
	L 0;
	CLR;
	SPPZ AAEQ;
AAEQ:	NOP 0;
	O(;
	);
	L 0;
	CLR;
	SPBI AAER;
AAER:	NOP 0;
	+ 0;
	/D;
	ACOS;
	>=D;
	FR Z 42;
	OW;
	LN;
	LEAVE;
	ITB;
	>=R;
	<=R;
	S M 0.4;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	+R;
	RND-;
	RLDA;
	BLD 0;
	<D;
	TRUNC;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	ZV Z 42;
	TAR2;
	ZV Z 42;
	O M 0.4;
	SSI;
	L 0;
	CLR;
	SPBB AAES;
AAES:	NOP 0;
	XOD;
	<>R;
	= M 0.4;
	LAR2;
	-I;
	NOP 0;
	L 0;
	CLR;
	SPBIN AAET;
AAET:	NOP 0;
	TAN;
	LC MW 0;
	TAR1;
	L 0;
	CLR;
	SPO AAEU;
AAEU:	NOP 0;
	DTR;
	-R;
	SLD;
	==I;
	RND+;
	+R;
	DEC 0;
	+ 0;
	+AR1;
	L 0;
	CLR;
	SPBI AAEV;
AAEV:	NOP 0;
	L 0;
	CLR;
	SPBI AAEW;
AAEW:	NOP 0;
	XN M 0.4;
	ABS;
	L 0;
	L 0;
	CLR;
	SPL AAEX;
AAEX:	NOP 0;
	O M 0.4;
	LEAVE;
	U(;
	);
	UC FC 44;
	RLDA;
	L 0;
	CLR;
	SPBB AAEY;
AAEY:	NOP 0;
	RND;
	UC FC 44;
	/I;
	TAW;
	ITD;
	LC MW 0;
	>D;
	SAVE;
	X TRUE;
	LAR1;
	O TRUE;
	==D;
	CLR;
	L 0;
	CLR;
	SPBI AAEZ;
AAEZ:	NOP 0;
	L 0;
	CLR;
	SPPZ AAFA;
AAFA:	NOP 0;
	SIN;
	<=R;
	INVI;
	==D;
	OD;
	-D;
	OW;
	RRDA;
	L 0;
	CLR;
	SPA AAFB;
AAFB:	NOP 0;
	<R;
	ZV Z 42;
	SLD;
	L 0;
	CLR;
	SPBI AAFC;
AAFC:	NOP 0;
	L 0;
	CLR;
	LOOP AAFD;
AAFD:	NOP 0;
	>I;
	SSI;
	R M 0.4;
	<D;
	TAD;
	ABS;
	POP;
	-D;
	CLR;
	ABS;
	ON M 0.4;
	AUF DB 42;
	UD;
	>=I;
	TAR1;
	*D;
	AUF DB 42;
	BLD 0;
	+R;
	/D;
	==I;
	TRUNC;
	SSD;
	U TRUE;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	TAW;
	X(;
	);
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	L 0;
	CLR;
	SPO AAFE;
AAFE:	NOP 0;
	EXP;
	>I;
	>D;
	XN FALSE;
	L 0;
	CLR;
	SPO AAFF;
AAFF:	NOP 0;
	RRD;
	>I;
	SAVE;
	RND+;
	UD;
	<>D;
	*R;
	TAR1;
	*D;
	OD;
	COS;
	NOP 0;
	==R;
	SIN;
	FN M 0.4;
	RLD;
	EXP;
	L 0;
	CLR;
	SPB AAFG;
AAFG:	NOP 0;
	O TRUE;
	NEGR;
	LAR2;
	LAR2;
	RND+;
	+D;
	FN M 0.4;
	*D;
	XOD;
	+ 0;
	ON(;
	);
	ABS;
	L 0;
	L 0;
	CLR;
	SPL AAFH;
AAFH:	NOP 0;
	ITD;
	>=I;
	TAR1;
	CLR;
	NEGD;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	XN M 0.4;
	U(;
	);
	L 0;
	CLR;
	SPU AAFI;
AAFI:	NOP 0;
	FR Z 42;
	<=I;
	LEAVE;
	INVD;
	XN(;
	);
	PUSH;
	NEGI;
	NOP 0;
	NEGR;
	TRUNC;
	L 0;
	CLR;
	SPMZ AAFJ;
AAFJ:	NOP 0;
	>=D;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	U M 0.4;
	L 0;
	L 0;
	CLR;
	SPL AAFK;
AAFK:	NOP 0;
	>=D;
	==D;
	OD;
	LC MW 0;
	<=R;
	<>I;
	U FALSE;
	ON M 0.4;
	+ 0;
	RND+;
	NOP 0;
	L 0;
	CLR;
	SPM AAFL;
AAFL:	NOP 0;
	X M 0.4;
	<=R;
	AUF DB 42;
	UN(;
	);
	<=I;
	COS;
	UW;
	>I;
	X(;
	);
	SLW;
	T MD 0;
	+D;
	L 0;
	SE T 42;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	==I;
	TAR;
	RRDA;
	TAW;
	XN TRUE;
	TAR2;
	UN FALSE;
	SRW;
	SQR;
	ASIN;
	==I;
	RLD;
	LAR2;
	= M 0.4;
	S M 0.4;
	L 0;
	CLR;
	SPM AAFM;
AAFM:	NOP 0;
	UC FC 44;
	>=D;
	X(;
	);
	<=I;
	L 0;
	L 0;
	CLR;
	SPL AAFN;
AAFN:	NOP 0;
	BLD 0;
	TAK;
	L 0;
	CLR;
	SPPZ AAFO;
AAFO:	NOP 0;
	+R;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	OW;
	L 0;
	CLR;
	SPBI AAFP;
AAFP:	NOP 0;
	TAR1;
	L 0;
	SI T 42;
	CC FC 43;
	ACOS;
	FN M 0.4;
	>I;
	PUSH;
	NEGR;
	ACOS;
	TAR;
	RND;
	LN;
	L 0;
	CLR;
	LOOP AAFQ;
AAFQ:	NOP 0;
	TAR1;
	SQR;
	SIN;
	SAVE;
	L 0;
	CLR;
	SPN AAFR;
AAFR:	NOP 0;
	ASIN;
	L 0;
	CLR;
	SPN AAFS;
AAFS:	NOP 0;
	ZV Z 42;
	/D;
	==R;
	SLW;
	XN(;
	);
	CLR;
	NOT;
	CLR;
	ACOS;
	SAVE;
	/D;
	==D;
	POP;
	ON(;
	);
	NOP 0;
	ENT;
	ENT;
	L 0;
	CLR;
	SPMZ AAFT;
AAFT:	NOP 0;
	>=I;
	LN;
	/I;
	TAN;
	UN(;
	);
	L 0;
	CLR;
	SPBB AAFU;
AAFU:	NOP 0;
	SET;
	L 0;
	CLR;
	SPZ AAFV;
AAFV:	NOP 0;
	/I;
	FP M 0.4;
	+AR1;
	L 0;
	SI T 42;
	NEGD;
	==R;
	SLD;
	TAD;
	==I;
	*I;
	POP;
	*D;
	>I;
	L 0;
	CLR;
	SPB AAFW;
AAFW:	NOP 0;
	DEC 0;
	TAD;
	ASIN;
	ENT;
	POP;
	U TRUE;
	UN FALSE;
	L 0;
	CLR;
	SPA AAFX;
AAFX:	NOP 0;
	L 0;
	CLR;
	SPZ AAFY;
AAFY:	NOP 0;
	L 0;
	CLR;
	LOOP AAFZ;
AAFZ:	NOP 0;
	*I;
	UN M 0.4;
	ITB;
	<D;
	LEAVE;
	SQR;
	XN(;
	);
	<D;
	UN FALSE;
	OW;
	NEGR;
	MOD;
	COS;
	TAR1;
	+I;
	<>R;
	*D;
	L 0;
	CLR;
	SPZ AAGA;
AAGA:	NOP 0;
	L 0;
	CLR;
	SPPZ AAGB;
AAGB:	NOP 0;
	INC 0;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	NOT;
	UN(;
	);
	==R;
	<>R;
	U(;
	);
	S M 0.4;
	L 0;
	CLR;
	SPA AAGC;
AAGC:	NOP 0;
	LAR2;
	TAN;
	SRD;
	UC FC 44;
	LAR2;
	SIN;
	L 0;
	CLR;
	SPA AAGD;
AAGD:	NOP 0;
	NEGR;
	L 0;
	SE T 42;
	>I;
	-I;
	ACOS;
	<>I;
	L 0;
	CLR;
	SPBN AAGE;
AAGE:	NOP 0;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	SRD;
	UW;
	L 0;
	CLR;
	SPS AAGF;
AAGF:	NOP 0;
	XN FALSE;
	ABS;
	SET;
	O(;
	);
	UN M 0.4;
	INVD;
	L 0;
	CLR;
	SPO AAGG;
AAGG:	NOP 0;
	NEGD;
	>D;
	ZV Z 42;
	L 0;
	CLR;
	SPBNB AAGH;
AAGH:	NOP 0;
	L 0;
	CLR;
	SPPZ AAGI;
AAGI:	NOP 0;
	<I;
	UN M 0.4;
	RLDA;
	ACOS;
	<=R;
	==D;
	+R;
	XOW;
	RND;
	RRDA;
	ENT;
	/I;
	= M 0.4;
	ABS;
	X TRUE;
	X M 0.4;
	TAR2;
	R M 0.4;
	L 0;
	CLR;
	SPN AAGJ;
AAGJ:	NOP 0;
	+AR1;
	ASIN;
	DEC 0;
	SQRT;
	SIN;
	L 0;
	CLR;
	SPBNB AAGK;
AAGK:	NOP 0;
	>I;
	SQRT;
	XN M 0.4;
	L 0;
	CLR;
	SPPZ AAGL;
AAGL:	NOP 0;
	>=R;
	TAR2;
	+D;
	SET;
	ATAN;
	==I;
	FR Z 42;
	ATAN;
	NOP 0;
	SQR;
	UW;
	S M 0.4;
	ABS;
	L 0;
	CLR;
	SPZ AAGM;
AAGM:	NOP 0;
	L 0;
	CLR;
	LOOP AAGN;
AAGN:	NOP 0;
	TAW;
	L 0;
	CLR;
	SPU AAGO;
AAGO:	NOP 0;
	>=R;
	R M 0.4;
	L 0;
	SV T 42;
	>I;
	OW;
	L 0;
	SV T 42;
	DTB;
	*I;
	*I;
	>=D;
	RND+;
	FP M 0.4;
	>=D;
	ZV Z 42;
	DTR;
	<=R;
	CC FC 43;
	==R;
	R M 0.4;
	L 0;
	BTI;
	RRD;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	LEAVE;
	+AR2;
	T MD 0;
	LEAVE;
	L 0;
	CLR;
	SPM AAGP;
AAGP:	NOP 0;
	L 0;
	CLR;
	SPN AAGQ;
AAGQ:	NOP 0;
	<=D;
	LAR1;
	XN(;
	);
	SSD;
	LAR2;
	L 0;
	CLR;
	SPO AAGR;
AAGR:	NOP 0;
	L 0;
	L 0;
	CLR;
	SPL AAGS;
AAGS:	NOP 0;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	O(;
	);
	/I;
	L 0;
	SI T 42;
	= M 0.4;
	L 0;
	CLR;
	SPZ AAGT;
AAGT:	NOP 0;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	TAR;
	ON FALSE;
	*D;
	L 0;
	CLR;
	SPBB AAGU;
AAGU:	NOP 0;
	R M 0.4;
	CLR;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	L 0;
	SI T 42;
	-R;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	+AR2;
	PUSH;
	X TRUE;
	DEC 0;
	ITD;
	L 0;
	CLR;
	SPM AAGV;
AAGV:	NOP 0;
	CC FC 43;
	SLW;
	RRDA;
	<=D;
	ON(;
	);
	TAR;
	FP M 0.4;
	+I;
	NOT;
	L 0;
	SI T 42;
	<=R;
	X FALSE;
	LAR1;
	LAR1;
	UW;
	L 0;
	SA T 42;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	<>R;
	-D;
	/D;
	L 0;
	CLR;
	SPBN AAGW;
AAGW:	NOP 0;
	*R;
	EXP;
	L 0;
	CLR;
	LOOP AAGX;
AAGX:	NOP 0;
	SET;
	UN(;
	);
	L 0;
	CLR;
	SPU AAGY;
AAGY:	NOP 0;
	X(;
	);
	L 0;
	CLR;
	SPMZ AAGZ;
AAGZ:	NOP 0;
	SAVE;
	POP;
	-R;
	L 0;
	CLR;
	SPBN AAHA;
AAHA:	NOP 0;
	LC MW 0;
	CC FC 43;
	<=D;
	L 0;
	CLR;
	SPU AAHB;
AAHB:	NOP 0;
	S M 0.4;
	BLD 0;
	<D;
	*I;
	L 0;
	CLR;
	SPZ AAHC;
AAHC:	NOP 0;
	/R;
	==D;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	NOT;
	L 0;
	CLR;
	SPZ AAHD;
AAHD:	NOP 0;
	ENT;
	MOD;
	L 0;
	CLR;
	SPMZ AAHE;
AAHE:	NOP 0;
	<=I;
	UW;
	CLR;
	TAN;
	L 0;
	SV T 42;
	+D;
	X M 0.4;
	+D;
	L 0;
	CLR;
	SPZ AAHF;
AAHF:	NOP 0;
	ITB;
	NEGD;
	+I;
	SRD;
	DTB;
	TAD;
	>D;
	==R;
	R M 0.4;
	L 0;
	CLR;
	SPBI AAHG;
AAHG:	NOP 0;
	FN M 0.4;
	L 0;
	SI T 42;
	OD;
	UW;
	ON TRUE;
	==D;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	MOD;
	==R;
	>R;
	ITB;
	<R;
	LAR1;
	XN TRUE;
	-D;
	RND+;
	LAR2;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	L 0;
	CLR;
	SPBN AAHH;
AAHH:	NOP 0;
	T MD 0;
	TRUNC;
	XOW;
	RND-;
	L 0;
	CLR;
	SPZ AAHI;
AAHI:	NOP 0;
	SSD;
	DTB;
	*D;
	DEC 0;
	LAR1;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	L 0;
	CLR;
	SPBN AAHJ;
AAHJ:	NOP 0;
	+R;
	RRDA;
	OW;
	COS;
	>R;
	INVI;
	CC FC 43;
	>D;
	LC MW 0;
	UN(;
	);
	SLD;
	/D;
	PUSH;
	FP M 0.4;
	L 0;
	SS T 42;
	>=I;
	L 0;
	CLR;
	SPBN AAHK;
AAHK:	NOP 0;
	NOT;
	>R;
	L 0;
	CLR;
	SPA AAHL;
AAHL:	NOP 0;
	TAR;
	L 0;
	SE T 42;
	>=D;
	ATAN;
	CLR;
	TAW;
	TAR;
	*I;
	U TRUE;
	UN(;
	);
	ABS;
	RRDA;
	/D;
	RND+;
	-R;
	S M 0.4;
	/D;
	TAD;
	UN TRUE;
	FN M 0.4;
	L 0;
	CLR;
	SPU AAHM;
AAHM:	NOP 0;
	>=D;
	>D;
	ON TRUE;
	SSD;
	>D;
	SSD;
	T MD 0;
	UN M 0.4;
	S M 0.4;
	X M 0.4;
	ZV Z 42;
	NEGR;
	<=D;
	TAK;
	UC FC 44;
	OW;
	TAN;
	<>I;
	L 0;
	CLR;
	SPBB AAHN;
AAHN:	NOP 0;
	RND+;
	L 0;
	CLR;
	SPO AAHO;
AAHO:	NOP 0;
	>=I;
	U(;
	);
	RND-;
	COS;
	TAR2;
	X(;
	);
	<>I;
	RLDA;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	UD;
	X M 0.4;
	L 0;
	SE T 42;
	+AR1;
	RND-;
	<D;
	L 0;
	CLR;
	SPBNB AAHP;
AAHP:	NOP 0;
	ASIN;
	U M 0.4;
	/I;
	RND-;
	DEC 0;
	SIN;
	L 0;
	BTD;
	NOT;
	UW;
	+D;
	XN(;
	);
	UW;
	XOD;
	L 0;
	SI T 42;
	L 0;
	SI T 42;
	PUSH;
	XN M 0.4;
	*R;
	SSD;
	XN TRUE;
	/D;
	LC MW 0;
	X M 0.4;
	+ 0;
	XN(;
	);
	-I;
	RND-;
	FP M 0.4;
	+AR2;
	L 0;
	CLR;
	SPU AAHQ;
AAHQ:	NOP 0;
	<>D;
	XN TRUE;
	XOD;
	L 0;
	CLR;
	LOOP AAHR;
AAHR:	NOP 0;
	<=R;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	SRW;
	ITB;
	<>D;
	X(;
	);
	TAR2;
	ON TRUE;
	INVI;
	XN FALSE;
	X TRUE;
	L 0;
	CLR;
	SPZ AAHS;
AAHS:	NOP 0;
	L 0;
	SE T 42;
	ABS;
	XOD;
	SLW;
	LC MW 0;
	ON FALSE;
	L 0;
	CLR;
	SPBB AAHT;
AAHT:	NOP 0;
	+ 0;
	U(;
	);
	L 0;
	CLR;
	SPMZ AAHU;
AAHU:	NOP 0;
	L 0;
	CLR;
	SPA AAHV;
AAHV:	NOP 0;
	>=I;
	*D;
	ATAN;
	SQR;
	LAR1;
	-R;
	L 0;
	CLR;
	LOOP AAHW;
AAHW:	NOP 0;
	L 0;
	BTD;
	RLDA;
	RLDA;
	*D;
	L 0;
	SS T 42;
	TDB;
	NOT;
	TAN;
	S M 0.4;
	ACOS;
	CC FC 43;
	ITB;
	XOD;
	L 0;
	CLR;
	SPBI AAHX;
AAHX:	NOP 0;
	L 0;
	CLR;
	SPM AAHY;
AAHY:	NOP 0;
	FP M 0.4;
	S M 0.4;
	L 0;
	CLR;
	SPPZ AAHZ;
AAHZ:	NOP 0;
	L 0;
	CLR;
	SPBI AAIA;
AAIA:	NOP 0;
	L 0;
	CLR;
	SPS AAIB;
AAIB:	NOP 0;
	T MD 0;
	CC FC 43;
	ASIN;
	<R;
	LAR2;
	*I;
	T MD 0;
	X TRUE;
	ATAN;
	L 0;
	L 0;
	CLR;
	SPL AAIC;
AAIC:	NOP 0;
	O(;
	);
	R M 0.4;
	SQRT;
	-D;
	L 0;
	SE T 42;
	<>R;
	UN FALSE;
	UC FC 44;
	LAR1;
	O FALSE;
	XN(;
	);
	RND+;
	-D;
	+D;
	-R;
	INC 0;
	O FALSE;
	TAR;
	*D;
	/D;
	LAR2;
	R M 0.4;
	DEC 0;
	>D;
	OW;
	-D;
	ABS;
	L 0;
	CLR;
	SPN AAID;
AAID:	NOP 0;
	L 0;
	CLR;
	SPB AAIE;
AAIE:	NOP 0;
	L DW#16#F5E4A471;
	U FALSE;
	RLDA;
	L 0;
	SS T 42;
	*R;
	ENT;
	<I;
	AUF DB 42;
	ZR Z 42;
	T MD 0;
	NEGD;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	L 0;
	CLR;
	SPBB AAIF;
AAIF:	NOP 0;
	RLD;
	INVI;
	>=I;
	<>D;
	= M 0.4;
	TAR;
	<=R;
	LAR2;
	SET;
	L 0;
	CLR;
	SPP AAIG;
AAIG:	NOP 0;
	-I;
	X(;
	);
	TAK;
	OD;
	L 0;
	CLR;
	SPBNB AAIH;
AAIH:	NOP 0;
	L 0;
	CLR;
	SPBIN AAII;
AAII:	NOP 0;
	<>R;
	<=R;
	+D;
	L 0;
	SV T 42;
	TAD;
	>=I;
	INVI;
	>D;
	RND+;
	RRD;
	U TRUE;
	PUSH;
	DEC 0;
	*D;
	SSI;
	PUSH;
	==D;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	SET;
	X(;
	);
	L 0;
	CLR;
	SPZ AAIJ;
AAIJ:	NOP 0;
	ABS;
	SRW;
	UW;
	LN;
	EXP;
	+AR1;
	= M 0.4;
	<=I;
	L 0;
	CLR;
	SPP AAIK;
AAIK:	NOP 0;
	= M 0.4;
	TAR;
	SSI;
	L 0;
	SS T 42;
	-I;
	<=I;
	PUSH;
	NOP 0;
	ITB;
	==D;
	ACOS;
	RRDA;
	O(;
	);
	>=I;
	L 0;
	SS T 42;
	==R;
	L 0;
	CLR;
	SPO AAIL;
AAIL:	NOP 0;
	<R;
	>R;
	L 0;
	CLR;
	SPM AAIM;
AAIM:	NOP 0;
	TAD;
	-I;
	L 0;
	SS T 42;
	L 0;
	CLR;
	SPBN AAIN;
AAIN:	NOP 0;
	S M 0.4;
	LC MW 0;
	DTR;
	PUSH;
	L 0;
	L 0;
	CLR;
	SPL AAIO;
AAIO:	NOP 0;
	<=I;
	L 0;
	CLR;
	SPO AAIP;
AAIP:	NOP 0;
	XOW;
	CLR;
	RRDA;
	>=R;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	+AR2;
	==R;
	>=R;
	CC FC 43;
	L 0;
	CLR;
	LOOP AAIQ;
AAIQ:	NOP 0;
	LEAVE;
	X FALSE;
	S M 0.4;
	XN TRUE;
	NEGI;
	DEC 0;
	SIN;
	UN TRUE;
	XOD;
	L 0;
	CLR;
	SPBNB AAIR;
AAIR:	NOP 0;
	L 0;
	CLR;
	SPO AAIS;
AAIS:	NOP 0;
	SLD;
	FR Z 42;
	SQRT;
	L 0;
	CLR;
	SPBIN AAIT;
AAIT:	NOP 0;
	TAR1;
	= M 0.4;
	ON(;
	);
	<>R;
	LAR1;
	SIN;
	SLD;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	INVD;
	+I;
	UC FC 44;
	<D;
	L 0;
	CLR;
	SPN AAIU;
AAIU:	NOP 0;
	L 0;
	CLR;
	SPP AAIV;
AAIV:	NOP 0;
	-I;
	SQR;
	==D;
	*D;
	L 0;
	SE T 42;
	ENT;
	==I;
	L 0;
	CLR;
	SPP AAIW;
AAIW:	NOP 0;
	RND-;
	SSI;
	>=I;
	TDB;
	TAR;
	L DW#16#24108E9A;
	U(;
	);
	L 0;
	CLR;
	SPBNB AAIX;
AAIX:	NOP 0;
	-R;
	COS;
	L DW#16#E6FDD7AF;
	L 0;
	CLR;
	SPPZ AAIY;
AAIY:	NOP 0;
	+AR1;
	L 0;
	CLR;
	SPN AAIZ;
AAIZ:	NOP 0;
	ITD;
	<>R;
	RLDA;
	L 0;
	SE T 42;
	SSI;
	RLDA;
	L 0;
	CLR;
	SPS AAJA;
AAJA:	NOP 0;
	RLDA;
	XN M 0.4;
	CLR;
	/R;
	L 0;
	SI T 42;
	TAR2;
	RND-;
	NEGR;
	BLD 0;
	/I;
	U(;
	);
	U(;
	);
	L 0;
	CLR;
	SPBN AAJB;
AAJB:	NOP 0;
	RRD;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	SSD;
	L 0;
	CLR;
	SPBB AAJC;
AAJC:	NOP 0;
	UD;
	O M 0.4;
	==I;
	ACOS;
	<>D;
	AUF DB 42;
	-D;
	SQRT;
	-D;
	XN TRUE;
	UN(;
	);
	INC 0;
	ENT;
	DTB;
	+D;
	PUSH;
	L 0;
	CLR;
	SPBB AAJD;
AAJD:	NOP 0;
	= M 0.4;
	-R;
	L 0;
	SI T 42;
	TAR;
	TAK;
	L 0;
	CLR;
	SPB AAJE;
AAJE:	NOP 0;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	<I;
	<=I;
	SAVE;
	/R;
	/D;
	L 0;
	CLR;
	LOOP AAJF;
AAJF:	NOP 0;
	POP;
	-D;
	<D;
	DTR;
	CC FC 43;
	L 0;
	SV T 42;
	SQR;
	RRDA;
	X FALSE;
	ON FALSE;
	L 0;
	CLR;
	SPU AAJG;
AAJG:	NOP 0;
	SLW;
	L 0;
	SS T 42;
	TAR1;
	<=D;
	UC FC 44;
	L 0;
	SE T 42;
	>D;
	L 0;
	CLR;
	SPPZ AAJH;
AAJH:	NOP 0;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	L 0;
	CLR;
	SPP AAJI;
AAJI:	NOP 0;
	>R;
	/R;
	L 0;
	CLR;
	SPBIN AAJJ;
AAJJ:	NOP 0;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	L 0;
	CLR;
	LOOP AAJK;
AAJK:	NOP 0;
	L 0;
	SI T 42;
	L 0;
	SV T 42;
	XOW;
	RLD;
	LEAVE;
	L 0;
	CLR;
	SPBIN AAJL;
AAJL:	NOP 0;
	SLW;
	X M 0.4;
	*D;
	L 0;
	CLR;
	SPMZ AAJM;
AAJM:	NOP 0;
	<>I;
	SIN;
	BLD 0;
	L 0;
	CLR;
	SPS AAJN;
AAJN:	NOP 0;
	U TRUE;
	AUF DB 42;
	+AR2;
	+AR1;
	RND;
	UN(;
	);
	BLD 0;
	SRW;
	>=R;
	UW;
	+R;
	>=D;
	FR Z 42;
	O FALSE;
	ITD;
	X M 0.4;
	LAR1;
	L 0;
	CLR;
	SPN AAJO;
AAJO:	NOP 0;
	COS;
	<=D;
	LN;
	INVD;
	LN;
	RRDA;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	SSD;
	ON(;
	);
	>D;
	L 0;
	SS T 42;
	NEGI;
	ENT;
	L 0;
	CLR;
	SPPZ AAJP;
AAJP:	NOP 0;
	SRW;
	UW;
	MOD;
	L 0;
	CLR;
	SPN AAJQ;
AAJQ:	NOP 0;
	<=R;
	TAR2;
	XOW;
	+I;
	XOD;
	/I;
	AUF DB 42;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	SLD;
	DTB;
	L DW#16#4C6A70F4;
	L 0;
	CLR;
	SPBIN AAJR;
AAJR:	NOP 0;
	L 0;
	CLR;
	SPBB AAJS;
AAJS:	NOP 0;
	NEGI;
	RLD;
	L 0;
	CLR;
	SPP AAJT;
AAJT:	NOP 0;
	SRW;
	*I;
	ENT;
	L 0;
	L 0;
	CLR;
	SPL AAJU;
AAJU:	NOP 0;
	L 0;
	CLR;
	SPBB AAJV;
AAJV:	NOP 0;
	>=I;
	DEC 0;
	XOD;
	+R;
	ABS;
	-I;
	>=D;
	L 0;
	CLR;
	SPBNB AAJW;
AAJW:	NOP 0;
	X TRUE;
	S M 0.4;
	-I;
	LAR2;
	ZV Z 42;
	SRW;
	NEGD;
	INVI;
	UD;
	L 0;
	CLR;
	SPA AAJX;
AAJX:	NOP 0;
	ENT;
	L 0;
	CLR;
	SPA AAJY;
AAJY:	NOP 0;
	>D;
	==I;
	NOP 0;
	RND-;
	FR Z 42;
	U(;
	);
	OW;
	TAD;
	TRUNC;
	UN(;
	);
	FN M 0.4;
	LN;
	L 0;
	CLR;
	SPMZ AAJZ;
AAJZ:	NOP 0;
	SSD;
	FN M 0.4;
	>D;
	UN M 0.4;
	TAK;
	<>R;
	EXP;
	SLW;
	SRW;
	INVI;
	L 0;
	CLR;
	SPBB AAKA;
AAKA:	NOP 0;
	L 0;
	CLR;
	SPM AAKB;
AAKB:	NOP 0;
	L 0;
	CLR;
	SPBB AAKC;
AAKC:	NOP 0;
	ON(;
	);
	SET;
	DEC 0;
	TRUNC;
	XOW;
	ON FALSE;
	SIN;
	L 0;
	BTI;
	ON TRUE;
	RRD;
	L 0;
	BTD;
	L 0;
	CLR;
	SPBNB AAKD;
AAKD:	NOP 0;
	ON FALSE;
	L 0;
	CLR;
	SPBIN AAKE;
AAKE:	NOP 0;
	INC 0;
	CC FC 43;
	==I;
	L 0;
	CLR;
	SPU AAKF;
AAKF:	NOP 0;
	L 0;
	CLR;
	SPBN AAKG;
AAKG:	NOP 0;
	TAR1;
	XOD;
	UW;
	RRD;
	<>D;
	L 0;
	SI T 42;
	SSI;
	L 0;
	CLR;
	SPA AAKH;
AAKH:	NOP 0;
	DTB;
	<>I;
	L 0;
	CLR;
	SPMZ AAKI;
AAKI:	NOP 0;
	>R;
	TAR2;
	ZV Z 42;
	L 0;
	BTD;
	ON M 0.4;
	L 0;
	CLR;
	LOOP AAKJ;
AAKJ:	NOP 0;
	L 0;
	CLR;
	SPBI AAKK;
AAKK:	NOP 0;
	INC 0;
	DTB;
	<=R;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	SQRT;
	ASIN;
	L 0;
	SE T 42;
	L 0;
	CLR;
	SPPZ AAKL;
AAKL:	NOP 0;
	SET;
	SQR;
	SAVE;
	L 0;
	BTD;
	>D;
	SRW;
	L 0;
	CLR;
	SPM AAKM;
AAKM:	NOP 0;
	L DW#16#01BF9E73;
	-R;
	RND+;
	T MD 0;
	TDB;
	L 0;
	CLR;
	SPMZ AAKN;
AAKN:	NOP 0;
	L 0;
	CLR;
	SPO AAKO;
AAKO:	NOP 0;
	BLD 0;
	DEC 0;
	O M 0.4;
	ZR Z 42;
	+D;
	RND+;
	ON(;
	);
	<I;
	SSI;
	L 0;
	CLR;
	SPS AAKP;
AAKP:	NOP 0;
	<>R;
	SQRT;
	RRDA;
	L 0;
	CLR;
	SPZ AAKQ;
AAKQ:	NOP 0;
	<I;
	L 0;
	CLR;
	SPBI AAKR;
AAKR:	NOP 0;
	*D;
	TAW;
	TAW;
	<>D;
	SRW;
	==R;
	TAR1;
	UC FC 44;
	/D;
	SIN;
	TAK;
	SSD;
	UD;
	NEGR;
	L DW#16#C9912032;
	UW;
	T MD 0;
	OW;
	+D;
	R M 0.4;
	LEAVE;
	<>I;
	ON(;
	);
	TAK;
	L 0;
	SI T 42;
	INVI;
	DEC 0;
	UD;
	<=D;
	<R;
	L 0;
	CLR;
	SPPZ AAKS;
AAKS:	NOP 0;
	L 0;
	SA T 42;
	LAR2;
	>I;
	INVD;
	BLD 0;
	RLD;
	CLR;
	L 0;
	SV T 42;
	T MD 0;
	O(;
	);
	TAR1;
	==D;
	L 0;
	SE T 42;
	SIN;
	TAR1;
	LEAVE;
	O(;
	);
	ENT;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	L 0;
	CLR;
	SPS AAKT;
AAKT:	NOP 0;
	XN M 0.4;
	ABS;
	ZV Z 42;
	U M 0.4;
	NEGR;
	+AR2;
	= M 0.4;
	XN TRUE;
	-I;
	X(;
	);
	OD;
	ON(;
	);
	XN(;
	);
	SSD;
	O TRUE;
	EXP;
	ITB;
	<>D;
	COS;
	/D;
	+R;
	T MD 0;
	MOD;
	MOD;
	S M 0.4;
	OD;
	<>D;
	*I;
	<I;
	L 0;
	BTI;
	UD;
	/R;
	OW;
	<=I;
	TAD;
	U M 0.4;
	XN M 0.4;
	L 0;
	CLR;
	SPBIN AAKU;
AAKU:	NOP 0;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	XOD;
	TAN;
	XOW;
	+R;
	RND;
	L DW#16#75EB89C2;
	==R;
	L 0;
	L 0;
	CLR;
	SPL AAKV;
AAKV:	NOP 0;
	ITD;
	<>I;
	O TRUE;
	X M 0.4;
	RND-;
	INVD;
	XN(;
	);
	FN M 0.4;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	O TRUE;
	SET;
	U(;
	);
	FR Z 42;
	XN TRUE;
	LAR1;
	TRUNC;
	OD;
	NEGR;
	O(;
	);
	>D;
	RRDA;
	L 0;
	CLR;
	SPBNB AAKW;
AAKW:	NOP 0;
	TRUNC;
	+AR1;
	L 0;
	CLR;
	SPP AAKX;
AAKX:	NOP 0;
	+AR1;
	SET;
	L 0;
	CLR;
	SPM AAKY;
AAKY:	NOP 0;
	RND+;
	L 0;
	CLR;
	SPO AAKZ;
AAKZ:	NOP 0;
	<D;
	L 0;
	SA T 42;
	TAW;
	LN;
	L 0;
	CLR;
	SPBIN AALA;
AALA:	NOP 0;
	L 0;
	L 0;
	CLR;
	SPL AALB;
AALB:	NOP 0;
	ON(;
	);
	POP;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	<=R;
	ASIN;
	POP;
	RRD;
	U(;
	);
	-I;
	+R;
	UW;
	L 0;
	CLR;
	SPP AALC;
AALC:	NOP 0;
	SIN;
	EXP;
	<=D;
	L 0;
	CLR;
	SPBIN AALD;
AALD:	NOP 0;
	MOD;
	L 0;
	BTD;
	UD;
	SLW;
	RND-;
	TAD;
	L 0;
	CLR;
	SPBIN AALE;
AALE:	NOP 0;
	<D;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	O(;
	);
	ENT;
	LN;
	SIN;
	POP;
	OW;
	<>D;
	*R;
	FR Z 42;
	ZV Z 42;
	INVD;
	L 0;
	CLR;
	SPMZ AALF;
AALF:	NOP 0;
	S M 0.4;
	TAR;
	*D;
	CLR;
	UD;
	ITD;
	UN(;
	);
	TDB;
	MOD;
	CC FC 43;
	CC FC 43;
	X FALSE;
	ITD;
	NOP 0;
	ENT;
	NEGR;
	SRW;
	NEGI;
	L 0;
	CLR;
	SPU AALG;
AALG:	NOP 0;
	L 0;
	CLR;
	SPO AALH;
AALH:	NOP 0;
	ON M 0.4;
	NEGD;
	ITD;
	<I;
	SRW;
	FR Z 42;
	CC FC 43;
	INVD;
	ABS;
	RND-;
	PUSH;
	L 0;
	CLR;
	SPM AALI;
AALI:	NOP 0;
	L 0;
	CLR;
	SPBN AALJ;
AALJ:	NOP 0;
	+R;
	SSI;
	XOW;
	+ 0;
	L 0;
	CLR;
	SPS AALK;
AALK:	NOP 0;
	ZR Z 42;
	+D;
	L 0;
	SE T 42;
	RLDA;
	SSI;
	FN M 0.4;
	SSD;
	L 0;
	CLR;
	SPP AALL;
AALL:	NOP 0;
	INVD;
	*D;
	L 0;
	CLR;
	SPN AALM;
AALM:	NOP 0;
	LN;
	XN FALSE;
	>=D;
	X M 0.4;
	ZR Z 42;
	PUSH;
	BLD 0;
	+AR2;
	SIN;
	L 0;
	CLR;
	SPBI AALN;
AALN:	NOP 0;
	==R;
	DTR;
	L 0;
	CLR;
	SPMZ AALO;
AALO:	NOP 0;
	RND;
	+R;
	INC 0;
	FR Z 42;
	RLDA;
	TAK;
	L 0;
	CLR;
	LOOP AALP;
AALP:	NOP 0;
	ZV Z 42;
	RLD;
	RLD;
	TAR2;
	>=R;
	/I;
	>=R;
	>D;
	XOD;
	RLD;
	L 0;
	BTD;
	OD;
	ON(;
	);
	UW;
	O FALSE;
	U(;
	);
	UN M 0.4;
	LN;
	>D;
	TRUNC;
	XN(;
	);
	<=D;
	O M 0.4;
	NEGR;
	L 0;
	SI T 42;
	TAR1;
	/D;
	ON(;
	);
	SLD;
	SRD;
	X M 0.4;
	UN M 0.4;
	XOW;
	PUSH;
	LN;
	ON M 0.4;
	X M 0.4;
	OW;
	L 0;
	L 0;
	CLR;
	SPL AALQ;
AALQ:	NOP 0;
	UD;
	L 0;
	CLR;
	SPBB AALR;
AALR:	NOP 0;
	X M 0.4;
	RRDA;
	ACOS;
	L 0;
	BTI;
	==I;
	SAVE;
	UW;
	<=D;
	RND-;
	DTB;
	UW;
	LC MW 0;
	/I;
	TDB;
	ABS;
	S M 0.4;
	/D;
	SQRT;
	TAR2;
	LEAVE;
	FR Z 42;
	TAD;
	L 0;
	CLR;
	SPBIN AALS;
AALS:	NOP 0;
	S M 0.4;
	O FALSE;
	SQRT;
	+R;
	MOD;
	PUSH;
	SLW;
	O(;
	);
	O M 0.4;
	>=R;
	NOT;
	RLDA;
	ATAN;
	L 0;
	CLR;
	SPMZ AALT;
AALT:	NOP 0;
	LEAVE;
	SAVE;
	OW;
	X FALSE;
	NEGD;
	INC 0;
	SLW;
	L 0;
	CLR;
	SPA AALU;
AALU:	NOP 0;
	XN FALSE;
	L 0;
	CLR;
	SPB AALV;
AALV:	NOP 0;
	XOD;
	LEAVE;
	O FALSE;
	L 0;
	CLR;
	SPN AALW;
AALW:	NOP 0;
	X M 0.4;
	NEGI;
	NOP 0;
	<D;
	ABS;
	R M 0.4;
	L 0;
	CLR;
	SPBIN AALX;
AALX:	NOP 0;
	>R;
	LEAVE;
	RND-;
	INC 0;
	*R;
	OD;
	L 0;
	CLR;
	SPMZ AALY;
AALY:	NOP 0;
	-R;
	>D;
	S M 0.4;
	RRDA;
	-I;
	UN(;
	);
	FN M 0.4;
	ATAN;
	TRUNC;
	R M 0.4;
	+I;
	CC FC 43;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	ABS;
	L 0;
	CLR;
	SPPZ AALZ;
AALZ:	NOP 0;
	UN TRUE;
	TAR;
	RLD;
	RND;
	+ 0;
	PUSH;
	MOD;
	ACOS;
	L 0;
	BTD;
	BLD 0;
	+R;
	NOT;
	L 0;
	CLR;
	SPBI AAMA;
AAMA:	NOP 0;
	L DW#16#B68E47FA;
	NOT;
	TDB;
	==R;
	+R;
	==R;
	*R;
	L 0;
	CLR;
	SPP AAMB;
AAMB:	NOP 0;
	+D;
	==I;
	CLR;
	UN M 0.4;
	L 0;
	CLR;
	SPS AAMC;
AAMC:	NOP 0;
	LAR2;
	+D;
	L 0;
	CLR;
	SPA AAMD;
AAMD:	NOP 0;
	FP M 0.4;
	==D;
	SET;
	L 0;
	BTD;
	ACOS;
	T MD 0;
	POP;
	POP;
	L 0;
	SE T 42;
	EXP;
	FP M 0.4;
	U FALSE;
	/I;
	PUSH;
	CLR;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	SET;
	L 0;
	CLR;
	SPPZ AAME;
AAME:	NOP 0;
	-R;
	ON M 0.4;
	L 0;
	CLR;
	SPBNB AAMF;
AAMF:	NOP 0;
	LN;
	*R;
	NOT;
	ENT;
	FR Z 42;
	DEC 0;
	L 0;
	SA T 42;
	>=R;
	+R;
	>=R;
	>D;
	TDB;
	L 0;
	CLR;
	SPO AAMG;
AAMG:	NOP 0;
	TDB;
	RRD;
	>=D;
	X(;
	);
	<R;
	ATAN;
	L 0;
	L 0;
	CLR;
	SPL AAMH;
AAMH:	NOP 0;
	COS;
	L 0;
	CLR;
	SPBIN AAMI;
AAMI:	NOP 0;
	SLD;
	R M 0.4;
	+D;
	LC MW 0;
	L DW#16#9DDE0188;
	TAR2;
	==I;
	<>D;
	L 0;
	CLR;
	SPO AAMJ;
AAMJ:	NOP 0;
	UN M 0.4;
	ABS;
	L 0;
	CLR;
	SPU AAMK;
AAMK:	NOP 0;
	+R;
	L 0;
	CLR;
	SPMZ AAML;
AAML:	NOP 0;
	LAR1;
	L 0;
	CLR;
	SPU AAMM;
AAMM:	NOP 0;
	ACOS;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	<>D;
	L 0;
	CLR;
	SPBIN AAMN;
AAMN:	NOP 0;
	L 0;
	CLR;
	SPM AAMO;
AAMO:	NOP 0;
	CC FC 43;
	INVI;
	SRW;
	L 0;
	CLR;
	SPN AAMP;
AAMP:	NOP 0;
	L 0;
	BTI;
	ABS;
	L 0;
	CLR;
	SPP AAMQ;
AAMQ:	NOP 0;
	L 0;
	CLR;
	SPBNB AAMR;
AAMR:	NOP 0;
	RLD;
	+AR1;
	FR Z 42;
	L 0;
	CLR;
	SPPZ AAMS;
AAMS:	NOP 0;
	MOD;
	L 0;
	CLR;
	SPB AAMT;
AAMT:	NOP 0;
	/R;
	-D;
	>I;
	LEAVE;
	INVI;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	XOD;
	ITB;
	TAK;
	U TRUE;
	NEGI;
	LAR1;
	L 0;
	CLR;
	SPBNB AAMU;
AAMU:	NOP 0;
	XN(;
	);
	EXP;
	RLDA;
	>D;
	L 0;
	CLR;
	SPO AAMV;
AAMV:	NOP 0;
	RND-;
	LC MW 0;
	==R;
	TAN;
	MOD;
	= M 0.4;
	T MD 0;
	SET;
	SRW;
	BLD 0;
	SQR;
	XOW;
	L 0;
	SI T 42;
	COS;
	XOD;
	ON TRUE;
	UD;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	NOT;
	==I;
	L DW#16#5AE1DBAD;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	XN TRUE;
	L 0;
	CLR;
	SPMZ AAMW;
AAMW:	NOP 0;
	ACOS;
	==I;
	O M 0.4;
	FN M 0.4;
	ZR Z 42;
	TAW;
	L 0;
	SV T 42;
	L 0;
	SS T 42;
	POP;
	+AR2;
	+AR1;
	TAW;
	T MD 0;
	/D;
	/R;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	NOP 0;
	RRDA;
	<=D;
	-I;
	U TRUE;
	FP M 0.4;
	L 0;
	CLR;
	SPBI AAMX;
AAMX:	NOP 0;
	SIN;
	NOT;
	>I;
	<D;
	*I;
	L 0;
	CLR;
	SPZ AAMY;
AAMY:	NOP 0;
	+I;
	TAR1;
	INVD;
	L 0;
	SA T 42;
	SLD;
	*I;
	SLW;
	SAVE;
	LAR1;
	TAR;
	L 0;
	CLR;
	SPP AAMZ;
AAMZ:	NOP 0;
	XN(;
	);
	L 0;
	CLR;
	SPBIN AANA;
AANA:	NOP 0;
	XN FALSE;
	XN M 0.4;
	+I;
	==I;
	<R;
	FR Z 42;
	L 0;
	SS T 42;
	<=R;
	PUSH;
	<>R;
	L 0;
	CLR;
	SPMZ AANB;
AANB:	NOP 0;
	ENT;
	ASIN;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	TRUNC;
	SQRT;
	L 0;
	BTD;
	L 0;
	BTD;
	ACOS;
	ABS;
	UN FALSE;
	TAR;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	ASIN;
	*R;
	UN M 0.4;
	NEGD;
	INVD;
	L 0;
	CLR;
	SPB AANC;
AANC:	NOP 0;
	X(;
	);
	+AR1;
	FP M 0.4;
	UD;
	L 0;
	BTD;
	-D;
	L 0;
	CLR;
	SPPZ AAND;
AAND:	NOP 0;
	DTR;
	TAR2;
	>I;
	AUF DB 42;
	RLD;
	OW;
	L 0;
	CLR;
	SPN AANE;
AANE:	NOP 0;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	*R;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	/R;
	NOP 0;
	>I;
	*I;
	/I;
	TAR2;
	<=R;
	L 0;
	CLR;
	SPBIN AANF;
AANF:	NOP 0;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	NOT;
	<>D;
	L 0;
	CLR;
	SPN AANG;
AANG:	NOP 0;
	<I;
	RND-;
	L 0;
	CLR;
	SPS AANH;
AANH:	NOP 0;
	>I;
	ITB;
	/D;
	<D;
	L 0;
	SV T 42;
	*R;
	COS;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	>D;
	+AR1;
	-R;
	TAN;
	L 0;
	BTD;
	SRD;
	UD;
	<=R;
	POP;
	<R;
	RLD;
	L 0;
	CLR;
	SPBB AANI;
AANI:	NOP 0;
	>D;
	L 0;
	BTD;
	L 0;
	CLR;
	SPN AANJ;
AANJ:	NOP 0;
	TAR;
	UN(;
	);
	+ 0;
	O M 0.4;
	SRD;
	<>D;
	DTB;
	-R;
	ENT;
	L 0;
	SI T 42;
	RRD;
	EXP;
	RLD;
	SIN;
	LAR2;
	RLD;
	<R;
	NOT;
	LEAVE;
	UN FALSE;
	L 0;
	CLR;
	SPBNB AANK;
AANK:	NOP 0;
	O TRUE;
	TAD;
	UD;
	L 0;
	CLR;
	SPBB AANL;
AANL:	NOP 0;
	>=R;
	TAR2;
	LEAVE;
	RRD;
	TAK;
	L 0;
	SV T 42;
	<>I;
	DEC 0;
	>I;
	TDB;
	XOD;
	-D;
	OD;
	X TRUE;
	XOD;
	NEGR;
	TAN;
	FP M 0.4;
	L DW#16#FFD2F491;
	TAR;
	AUF DB 42;
	*I;
	SET;
	LAR1;
	<I;
	RND+;
	NEGI;
	NOP 0;
	*I;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	ASIN;
	<R;
	>D;
	INVD;
	INVD;
	ON(;
	);
	INC 0;
	*I;
	XOW;
	L 0;
	CLR;
	SPB AANM;
AANM:	NOP 0;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	UD;
	>=R;
	L 0;
	CLR;
	SPM AANN;
AANN:	NOP 0;
	L 0;
	CLR;
	SPBNB AANO;
AANO:	NOP 0;
	L 0;
	CLR;
	SPBNB AANP;
AANP:	NOP 0;
	DEC 0;
	TDB;
	L 0;
	SE T 42;
	SAVE;
	<>D;
	LN;
	ON(;
	);
	L 0;
	L 0;
	CLR;
	SPL AANQ;
AANQ:	NOP 0;
	<=I;
	==D;
	L DW#16#64880945;
	<D;
	+AR1;
	TDB;
	SIN;
	MOD;
	TAR;
	R M 0.4;
	CLR;
	SQRT;
	L 0;
	SE T 42;
	L 0;
	CLR;
	SPB AANR;
AANR:	NOP 0;
	*D;
	TAR1;
	SRD;
	L 0;
	CLR;
	SPPZ AANS;
AANS:	NOP 0;
	+AR2;
	U M 0.4;
	CLR;
	TAR2;
	+ 0;
	X(;
	);
	XOW;
	ABS;
	NEGR;
	ASIN;
	NEGD;
	RRD;
	TDB;
	L 0;
	CLR;
	SPM AANT;
AANT:	NOP 0;
	L 0;
	CLR;
	SPBN AANU;
AANU:	NOP 0;
	L 0;
	CLR;
	LOOP AANV;
AANV:	NOP 0;
	TAK;
	+AR1;
	==D;
	LEAVE;
	SRD;
	+I;
	U(;
	);
	XN FALSE;
	TAR2;
	X M 0.4;
	>=I;
	<>R;
	LAR1;
	TAR1;
	U M 0.4;
	ASIN;
	INVI;
	==D;
	L 0;
	CLR;
	SPO AANW;
AANW:	NOP 0;
	<>R;
	L 0;
	L 0;
	CLR;
	SPL AANX;
AANX:	NOP 0;
	CLR;
	+D;
	LC MW 0;
	NOT;
	/D;
	<R;
	UN(;
	);
	ABS;
	L 0;
	CLR;
	SPS AANY;
AANY:	NOP 0;
	TRUNC;
	ASIN;
	CLR;
	SAVE;
	U M 0.4;
	NEGD;
	SRW;
	R M 0.4;
	==D;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	TAD;
	L 0;
	SS T 42;
	LAR2;
	O M 0.4;
	O M 0.4;
	+I;
	<I;
	TAN;
	==D;
	SRW;
	= M 0.4;
	RND;
	-R;
	SET;
	FP M 0.4;
	FP M 0.4;
	L 0;
	CLR;
	SPN AANZ;
AANZ:	NOP 0;
	*D;
	L 0;
	CLR;
	SPBIN AAOA;
AAOA:	NOP 0;
	>D;
	+R;
	<>D;
	<D;
	XN(;
	);
	OW;
	LEAVE;
	O M 0.4;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	<R;
	LAR1;
	*I;
	NEGD;
	<=D;
	LN;
	LAR2;
	NEGR;
	SET;
	FN M 0.4;
	>D;
	>=I;
	NOP 0;
	-R;
	*I;
	ASIN;
	L 0;
	CLR;
	SPN AAOB;
AAOB:	NOP 0;
	>D;
	L DW#16#159152F2;
	PUSH;
	SET;
	SET;
	UC FC 44;
	L 0;
	CLR;
	SPBN AAOC;
AAOC:	NOP 0;
	U TRUE;
	INVD;
	L 0;
	SS T 42;
	UC FC 44;
	L 0;
	SV T 42;
	ITD;
	/R;
	L 0;
	CLR;
	SPBI AAOD;
AAOD:	NOP 0;
	UN(;
	);
	RND-;
	RRD;
	-R;
	<>I;
	RND-;
	RLDA;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	= M 0.4;
	OW;
	ON M 0.4;
	+D;
	L 0;
	CLR;
	SPP AAOE;
AAOE:	NOP 0;
	==D;
	*R;
	INC 0;
	COS;
	-D;
	XOD;
	<=R;
	SSD;
	= M 0.4;
	X M 0.4;
	NOP 0;
	XN(;
	);
	ON M 0.4;
	AUF DB 42;
	NEGR;
	X FALSE;
	ABS;
	L 0;
	SI T 42;
	L 0;
	CLR;
	SPBB AAOF;
AAOF:	NOP 0;
	RRDA;
	SIN;
	TAN;
	SQR;
	NOT;
	UD;
	UD;
	==R;
	L 0;
	CLR;
	SPB AAOG;
AAOG:	NOP 0;
	NOT;
	L 0;
	CLR;
	SPZ AAOH;
AAOH:	NOP 0;
	S M 0.4;
	L 0;
	SV T 42;
	INVD;
	==R;
	UD;
	L 0;
	CLR;
	SPPZ AAOI;
AAOI:	NOP 0;
	/R;
	NOP 0;
	X(;
	);
	L 0;
	CLR;
	SPZ AAOJ;
AAOJ:	NOP 0;
	ATAN;
	RND-;
	O(;
	);
	FR Z 42;
	SET;
	ATAN;
	>I;
	TAR1;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	UC FC 44;
	O(;
	);
	L 0;
	CLR;
	SPZ AAOK;
AAOK:	NOP 0;
	<=R;
	<I;
	ON M 0.4;
	>D;
	O M 0.4;
	>R;
	RLDA;
	-I;
	L 0;
	SA T 42;
	L 0;
	SS T 42;
	ZR Z 42;
	<R;
	/D;
	<=I;
	TDB;
	<I;
	UN TRUE;
	ASIN;
	L 0;
	CLR;
	SPA AAOL;
AAOL:	NOP 0;
	UW;
	X(;
	);
	AUF DB 42;
	+AR1;
	R M 0.4;
	RLDA;
	TAR1;
	L 0;
	SV T 42;
	+D;
	O(;
	);
	RLDA;
	INC 0;
	<R;
	*D;
	<>R;
	ZV Z 42;
	FP M 0.4;
	DEC 0;
	>I;
	RND;
	L 0;
	SV T 42;
	U M 0.4;
	XN FALSE;
	FR Z 42;
	XN TRUE;
	-D;
	-R;
	<=D;
	L 0;
	BTI;
	ON TRUE;
	TAD;
	L 0;
	CLR;
	SPM AAOM;
AAOM:	NOP 0;
	L DW#16#B864CA08;
	L 0;
	CLR;
	SPA AAON;
AAON:	NOP 0;
	R M 0.4;
	DEC 0;
	/D;
	<I;
	RRDA;
	UN(;
	);
	L 0;
	BTI;
	TAD;
	L 0;
	SS T 42;
	XN TRUE;
	XN(;
	);
	SSI;
	L 0;
	CLR;
	SPBN AAOO;
AAOO:	NOP 0;
	L 0;
	CLR;
	SPZ AAOP;
AAOP:	NOP 0;
	L 0;
	CLR;
	SPPZ AAOQ;
AAOQ:	NOP 0;
	SET;
	PUSH;
	TAR1;
	O M 0.4;
	*D;
	INVI;
	L 0;
	CLR;
	SPBNB AAOR;
AAOR:	NOP 0;
	LEAVE;
	L 0;
	CLR;
	SPO AAOS;
AAOS:	NOP 0;
	FR Z 42;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	*D;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	RRD;
	DTR;
	XOD;
	FR Z 42;
	<=D;
	UN M 0.4;
	EXP;
	U FALSE;
	OD;
	-I;
	O M 0.4;
	L 0;
	CLR;
	SPU AAOT;
AAOT:	NOP 0;
	U M 0.4;
	MOD;
	L 0;
	CLR;
	SPS AAOU;
AAOU:	NOP 0;
	FP M 0.4;
	INVD;
	OW;
	RND+;
	COS;
	RLD;
	ON(;
	);
	<D;
	L 0;
	CLR;
	SPB AAOV;
AAOV:	NOP 0;
	CLR;
	XN FALSE;
	L 0;
	SA T 42;
	LN;
	/D;
	TAR2;
	NOT;
	+AR2;
	SAVE;
	L 0;
	SI T 42;
	<>D;
	/R;
	R M 0.4;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	INC 0;
	ON(;
	);
	ATAN;
	==D;
	RND+;
	L 0;
	CLR;
	SPBNB AAOW;
AAOW:	NOP 0;
	ZR Z 42;
	L 0;
	CLR;
	SPN AAOX;
AAOX:	NOP 0;
	/R;
	L 0;
	CLR;
	SPPZ AAOY;
AAOY:	NOP 0;
	L 0;
	CLR;
	SPP AAOZ;
AAOZ:	NOP 0;
	TAR;
	L 0;
	CLR;
	SPA AAPA;
AAPA:	NOP 0;
	TRUNC;
	R M 0.4;
	INVI;
	<>D;
	BLD 0;
	==I;
	==R;
	==I;
	<R;
	TAR;
	SSI;
	L 0;
	CLR;
	SPN AAPB;
AAPB:	NOP 0;
	EXP;
	<I;
	UD;
	+ 0;
	NEGI;
	TAR;
	L 0;
	CLR;
	SPS AAPC;
AAPC:	NOP 0;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	AUF DB 42;
	<I;
	CLR;
	<>R;
	L 0;
	CLR;
	SPO AAPD;
AAPD:	NOP 0;
	CC FC 43;
	X FALSE;
	L 0;
	CLR;
	SPPZ AAPE;
AAPE:	NOP 0;
	>=D;
	CLR;
	L DW#16#F7E9101D;
	ABS;
	L 0;
	SE T 42;
	U(;
	);
	L 0;
	CLR;
	SPBIN AAPF;
AAPF:	NOP 0;
	ZR Z 42;
	<=R;
	UN TRUE;
	TAR;
	POP;
	TAK;
	L DW#16#183FEA70;
	FP M 0.4;
	>D;
	>=I;
	ON M 0.4;
	ON(;
	);
	TAW;
	==D;
	DTR;
	SQR;
	/D;
	NOT;
	BLD 0;
	NOP 0;
	ZR Z 42;
	R M 0.4;
	XN M 0.4;
	X(;
	);
	DTR;
	LAR2;
	<=I;
	CLR;
	L 0;
	CLR;
	SPMZ AAPG;
AAPG:	NOP 0;
	>=I;
	X TRUE;
	U(;
	);
	>=R;
	DEC 0;
	ACOS;
	ABS;
	RLDA;
	UN TRUE;
	ASIN;
	<=R;
	/I;
	NEGD;
	L 0;
	BTD;
	L 0;
	L 0;
	CLR;
	SPL AAPH;
AAPH:	NOP 0;
	L 0;
	CLR;
	SPB AAPI;
AAPI:	NOP 0;
	T MD 0;
	<=D;
	O FALSE;
	L 0;
	CLR;
	SPBI AAPJ;
AAPJ:	NOP 0;
	RLDA;
	LN;
	TAK;
	SRW;
	ON(;
	);
	SET;
	L 0;
	CLR;
	SPB AAPK;
AAPK:	NOP 0;
	-R;
	>D;
	COS;
	INVI;
	UW;
	L DW#16#CB7B0B3A;
	+R;
	+ 0;
	SRW;
	XOD;
	SRD;
	-I;
	LEAVE;
	RRDA;
	L 0;
	CLR;
	SPM AAPL;
AAPL:	NOP 0;
	*R;
	L 0;
	CLR;
	SPA AAPM;
AAPM:	NOP 0;
	ITB;
	U TRUE;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	TAW;
	UN TRUE;
	O(;
	);
	SSD;
	OW;
	+ 0;
	BLD 0;
	TRUNC;
	<>R;
	FN M 0.4;
	L DW#16#A8284442;
	TDB;
	XOW;
	O(;
	);
	TAW;
	+AR1;
	*R;
	/I;
	<=R;
	L 0;
	BTI;
	RND+;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	L 0;
	CLR;
	SPP AAPN;
AAPN:	NOP 0;
	+ 0;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	UN TRUE;
	INC 0;
	LEAVE;
	<D;
	LEAVE;
	ITD;
	RRD;
	OD;
	L 0;
	CLR;
	SPZ AAPO;
AAPO:	NOP 0;
	<=R;
	RLD;
	ON FALSE;
	O(;
	);
	TRUNC;
	CC FC 43;
	TAW;
	XN M 0.4;
	UW;
	SRW;
	U M 0.4;
	L 0;
	CLR;
	SPMZ AAPP;
AAPP:	NOP 0;
	INVI;
	==D;
	+I;
	L 0;
	BTI;
	L 0;
	CLR;
	SPM AAPQ;
AAPQ:	NOP 0;
	ON(;
	);
	XN M 0.4;
	>=D;
	NOP 0;
	<D;
	<>I;
	UW;
	-D;
	= M 0.4;
	/D;
	ABS;
	NOP 0;
	FN M 0.4;
	L 0;
	CLR;
	LOOP AAPR;
AAPR:	NOP 0;
	L 0;
	CLR;
	SPO AAPS;
AAPS:	NOP 0;
	L 0;
	CLR;
	SPM AAPT;
AAPT:	NOP 0;
	<>D;
	<>R;
	ATAN;
	SRD;
	L 0;
	CLR;
	SPP AAPU;
AAPU:	NOP 0;
	<=R;
	ENT;
	+ 0;
	TAD;
	NOP 0;
	<=R;
	MOD;
	L 0;
	CLR;
	SPS AAPV;
AAPV:	NOP 0;
	L 0;
	CLR;
	SPBI AAPW;
AAPW:	NOP 0;
	<=I;
	L 0;
	BTI;
	U M 0.4;
	DEC 0;
	/R;
	INC 0;
	O FALSE;
	CC FC 43;
	L 0;
	CLR;
	SPP AAPX;
AAPX:	NOP 0;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	TAW;
	LEAVE;
	FP M 0.4;
	RLDA;
	<D;
	L 0;
	CLR;
	SPMZ AAPY;
AAPY:	NOP 0;
	R M 0.4;
	RND+;
	-I;
	L 0;
	CLR;
	SPP AAPZ;
AAPZ:	NOP 0;
	<R;
	SET;
	L 0;
	CLR;
	SPU AAQA;
AAQA:	NOP 0;
	T MD 0;
	O M 0.4;
	AUF DB 42;
	NEGI;
	L DW#16#B173FCDF;
	*I;
	ZV Z 42;
	==I;
	U M 0.4;
	U(;
	);
	-R;
	LAR1;
	COS;
	<R;
	LN;
	RRD;
	MOD;
	*I;
	XOD;
	MOD;
	FN M 0.4;
	SRW;
	+AR1;
	TAD;
	>R;
	TAR;
	= M 0.4;
	O TRUE;
	XN M 0.4;
	L 0;
	CLR;
	SPP AAQB;
AAQB:	NOP 0;
	ZR Z 42;
	FP M 0.4;
	= M 0.4;
	+I;
	>=R;
	MOD;
	>R;
	R M 0.4;
	TAK;
	CLR;
	L 0;
	CLR;
	LOOP AAQC;
AAQC:	NOP 0;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	SLD;
	UN TRUE;
	<R;
	UC FC 44;
	ATAN;
	<>R;
	UN(;
	);
	FN M 0.4;
	L 0;
	CLR;
	SPMZ AAQD;
AAQD:	NOP 0;
	INVD;
	ITD;
	EXP;
	PUSH;
	OD;
	AUF DB 42;
	L 0;
	CLR;
	SPBN AAQE;
AAQE:	NOP 0;
	L 0;
	CLR;
	SPBIN AAQF;
AAQF:	NOP 0;
	RND+;
	SAVE;
	U(;
	);
	/R;
	DEC 0;
	TAK;
	RLD;
	==R;
	UN(;
	);
	+D;
	U M 0.4;
	ASIN;
	SET;
	L 0;
	CLR;
	SPBI AAQG;
AAQG:	NOP 0;
	SET;
	SRW;
	INVI;
	SAVE;
	U FALSE;
	>=R;
	L 0;
	CLR;
	SPBNB AAQH;
AAQH:	NOP 0;
	S M 0.4;
	SLW;
	>I;
	L 0;
	CLR;
	SPS AAQI;
AAQI:	NOP 0;
	ABS;
	SSD;
	RLD;
	AUF DB 42;
	CLR;
	XOD;
	*R;
	L 0;
	BTD;
	*D;
	+R;
	*D;
	L 0;
	BTD;
	T MD 0;
	XN TRUE;
	LAR1;
	SSI;
	AUF DB 42;
	TAD;
	TDB;
	LEAVE;
	ON(;
	);
	<=D;
	SAVE;
	NOT;
	-I;
	OD;
	LN;
	NOP 0;
	RND;
	PUSH;
	ON(;
	);
	*R;
	L 0;
	SA T 42;
	COS;
	UD;
	SLW;
	DEC 0;
	RND+;
	SLW;
	L 0;
	CLR;
	SPBIN AAQJ;
AAQJ:	NOP 0;
	S M 0.4;
	ABS;
	O FALSE;
	<I;
	T MD 0;
	<=R;
	<R;
	NEGD;
	DTB;
	<=I;
	X TRUE;
	S M 0.4;
	ATAN;
	INVI;
	>=D;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	ZR Z 42;
	L 0;
	CLR;
	SPP AAQK;
AAQK:	NOP 0;
	XN(;
	);
	SET;
	*R;
	POP;
	ABS;
	PUSH;
	L 0;
	CLR;
	SPPZ AAQL;
AAQL:	NOP 0;
	L 0;
	L 0;
	CLR;
	SPL AAQM;
AAQM:	NOP 0;
	L 0;
	SA T 42;
	TAR2;
	ON M 0.4;
	NOP 0;
	L 0;
	SA T 42;
	COS;
	<>I;
	SIN;
	<=D;
	>=D;
	INC 0;
	NOP 0;
	BLD 0;
	FN M 0.4;
	==I;
	LEAVE;
	FN M 0.4;
	L 0;
	CLR;
	SPBB AAQN;
AAQN:	NOP 0;
	UD;
	-I;
	LN;
	AUF DB 42;
	-R;
	SRD;
	DEC 0;
	UC FC 44;
	SLW;
	ON FALSE;
	L 0;
	L 0;
	CLR;
	SPL AAQO;
AAQO:	NOP 0;
	SQRT;
	<D;
	UC FC 44;
	SQR;
	ON TRUE;
	L 0;
	CLR;
	SPMZ AAQP;
AAQP:	NOP 0;
	RND+;
	U(;
	);
	SLW;
	TDB;
	/D;
	XN M 0.4;
	L 0;
	CLR;
	LOOP AAQQ;
AAQQ:	NOP 0;
	L 0;
	CLR;
	SPO AAQR;
AAQR:	NOP 0;
	L 0;
	CLR;
	SPZ AAQS;
AAQS:	NOP 0;
	L 0;
	CLR;
	SPB AAQT;
AAQT:	NOP 0;
	RLD;
	FN M 0.4;
	RND;
	<>D;
	L 0;
	CLR;
	SPBIN AAQU;
AAQU:	NOP 0;
	LAR2;
	L 0;
	CLR;
	SPM AAQV;
AAQV:	NOP 0;
	TDB;
	SIN;
	CC FC 43;
	SET;
	ITD;
	LAR2;
	NEGD;
	EXP;
	SRD;
	L 0;
	SS T 42;
	/D;
	O(;
	);
	L 0;
	SE T 42;
	<>R;
	X(;
	);
	L 0;
	CLR;
	SPZ AAQW;
AAQW:	NOP 0;
	L 0;
	SI T 42;
	SQRT;
	<>D;
	UW;
	INC 0;
	UN FALSE;
	DTB;
	INVI;
	O(;
	);
	L DW#16#08775804;
	U(;
	);
	+D;
	DTR;
	L 0;
	L 0;
	CLR;
	SPL AAQX;
AAQX:	NOP 0;
	*D;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	L 0;
	SI T 42;
	ABS;
	>=I;
	UN FALSE;
	/D;
	RLD;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	T MD 0;
	L 0;
	BTI;
	SLW;
	NOP 0;
	PUSH;
	*I;
	-I;
	>R;
	ZR Z 42;
	CLR;
	L 0;
	CLR;
	SPBN AAQY;
AAQY:	NOP 0;
	UN TRUE;
	U(;
	);
	>R;
	DEC 0;
	NEGD;
	TAW;
	TAD;
	INVD;
	TDB;
	EXP;
	L 0;
	SE T 42;
	XN M 0.4;
	O M 0.4;
	SLW;
	==D;
	<=R;
	SET;
	O M 0.4;
	TAD;
	LC MW 0;
	UC FC 44;
	L 0;
	CLR;
	SPS AAQZ;
AAQZ:	NOP 0;
	L 0;
	L 0;
	CLR;
	SPL AARA;
AARA:	NOP 0;
	TAN;
	MOD;
	*I;
	TAR2;
	LC MW 0;
	NEGR;
	SSI;
	L 0;
	CLR;
	SPO AARB;
AARB:	NOP 0;
	L 0;
	SA T 42;
	ABS;
	BLD 0;
	FP M 0.4;
	UN M 0.4;
	L 0;
	SV T 42;
	/D;
	ENT;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	UC FC 44;
	L 0;
	CLR;
	SPBN AARC;
AARC:	NOP 0;
	L 0;
	CLR;
	SPBIN AARD;
AARD:	NOP 0;
	==I;
	SLD;
	X(;
	);
	L 0;
	CLR;
	LOOP AARE;
AARE:	NOP 0;
	L 0;
	L 0;
	CLR;
	SPL AARF;
AARF:	NOP 0;
	L 0;
	CLR;
	SPPZ AARG;
AARG:	NOP 0;
	L 0;
	L 0;
	CLR;
	SPL AARH;
AARH:	NOP 0;
	ZR Z 42;
	L 0;
	CLR;
	SPBIN AARI;
AARI:	NOP 0;
	ITD;
	<=D;
	L 0;
	SS T 42;
	RND-;
	O(;
	);
	SET;
	SQRT;
	L 0;
	CLR;
	SPP AARJ;
AARJ:	NOP 0;
	>D;
	U TRUE;
	L 0;
	CLR;
	SPBI AARK;
AARK:	NOP 0;
	ZR Z 42;
	COS;
	SQRT;
	*R;
	ON FALSE;
	+I;
	TAW;
	XOW;
	SLW;
	+ 0;
	L 0;
	SI T 42;
	L 0;
	CLR;
	SPBIN AARL;
AARL:	NOP 0;
	>=R;
	POP;
	ITB;
	L 0;
	CLR;
	SPBI AARM;
AARM:	NOP 0;
	SAVE;
	SSD;
	<=I;
	ZR Z 42;
	ENT;
	ITB;
	L 0;
	CLR;
	SPU AARN;
AARN:	NOP 0;
	SET;
	TAW;
	/I;
	TAD;
	L 0;
	CLR;
	SPS AARO;
AARO:	NOP 0;
	COS;
	L 0;
	CLR;
	SPMZ AARP;
AARP:	NOP 0;
	/D;
	ZR Z 42;
	BLD 0;
	L 0;
	CLR;
	SPBI AARQ;
AARQ:	NOP 0;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	<I;
	SSD;
	UN(;
	);
	BLD 0;
	+AR2;
	= M 0.4;
	SSD;
	DTB;
	RRDA;
	<I;
	+R;
	OW;
	L 0;
	CLR;
	SPBIN AARR;
AARR:	NOP 0;
	LN;
	UN(;
	);
	<=D;
	>D;
	INVI;
	+I;
	EXP;
	INC 0;
	TAR2;
	<D;
	L 0;
	CLR;
	SPN AARS;
AARS:	NOP 0;
	ITB;
	S M 0.4;
	SRD;
	L 0;
	CLR;
	SPU AART;
AART:	NOP 0;
	L 0;
	BTI;
	L 0;
	CLR;
	SPN AARU;
AARU:	NOP 0;
	O(;
	);
	UN M 0.4;
	TAR;
	L 0;
	L 0;
	CLR;
	SPL AARV;
AARV:	NOP 0;
	NEGI;
	>=R;
	+AR1;
	<>R;
	RLD;
	SET;
	==D;
	ATAN;
	ASIN;
	SQRT;
	ASIN;
	SRW;
	-R;
	UN M 0.4;
	ON FALSE;
	/D;
	ON M 0.4;
	L 0;
	CLR;
	SPM AARW;
AARW:	NOP 0;
	OW;
	ITD;
	X M 0.4;
	UN M 0.4;
	L DW#16#E0821918;
	L 0;
	CLR;
	SPZ AARX;
AARX:	NOP 0;
	==D;
	FP M 0.4;
	-R;
	RRDA;
	NOP 0;
	L 0;
	CLR;
	SPS AARY;
AARY:	NOP 0;
	<R;
	X(;
	);
	XN TRUE;
	L 0;
	CLR;
	SPBNB AARZ;
AARZ:	NOP 0;
	TAR1;
	L 0;
	SA T 42;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	UW;
	L 0;
	CLR;
	LOOP AASA;
AASA:	NOP 0;
	ATAN;
	<>D;
	+I;
	RLD;
	+ 0;
	ITD;
	<R;
	SQRT;
	X M 0.4;
	RND;
	TAD;
	==D;
	NEGD;
	XN M 0.4;
	NOP 0;
	L 0;
	SI T 42;
	>=R;
	>=I;
	-D;
	ON TRUE;
	ZV Z 42;
	XOW;
	U(;
	);
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	U(;
	);
	==I;
	XN M 0.4;
	U(;
	);
	>I;
	SIN;
	LAR2;
	+R;
	>=I;
	TAK;
	LC MW 0;
	SLW;
	==R;
	INVD;
	O M 0.4;
	L 0;
	CLR;
	SPO AASB;
AASB:	NOP 0;
	COS;
	FN M 0.4;
	L 0;
	SA T 42;
	L 0;
	CLR;
	SPA AASC;
AASC:	NOP 0;
	UC FC 44;
	>D;
	COS;
	FP M 0.4;
	L 0;
	SV T 42;
	<I;
	L 0;
	CLR;
	SPBN AASD;
AASD:	NOP 0;
	>I;
	==I;
	RLDA;
	DTR;
	UC FC 44;
	INVI;
	AUF DB 42;
	L 0;
	SA T 42;
	INVI;
	+ 0;
	EXP;
	L 0;
	CLR;
	SPBI AASE;
AASE:	NOP 0;
	>R;
	X TRUE;
	NEGI;
	SLD;
	L 0;
	CLR;
	SPMZ AASF;
AASF:	NOP 0;
	RND+;
	U M 0.4;
	ON M 0.4;
	SET;
	<>I;
	DEC 0;
	RRD;
	<=D;
	CLR;
	L 0;
	SV T 42;
	R M 0.4;
	FN M 0.4;
	ZV Z 42;
	TRUNC;
	TAR1;
	L 0;
	CLR;
	SPBI AASG;
AASG:	NOP 0;
	AUF DB 42;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	U(;
	);
	FN M 0.4;
	<=R;
	X TRUE;
	+D;
	L 0;
	CLR;
	SPN AASH;
AASH:	NOP 0;
	ASIN;
	>I;
	SAVE;
	XN FALSE;
	>D;
	>=R;
	L 0;
	CLR;
	SPMZ AASI;
AASI:	NOP 0;
	+ 0;
	LAR1;
	TDB;
	CLR;
	/D;
	+I;
	ITB;
	>I;
	SQR;
	SQR;
	TAR1;
	L 0;
	CLR;
	SPA AASJ;
AASJ:	NOP 0;
	-R;
	SRW;
	COS;
	<R;
	<>I;
	==D;
	ON(;
	);
	<>R;
	FP M 0.4;
	SIN;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	SLD;
	INC 0;
	LAR1;
	ITB;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	+R;
	+ 0;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	UN FALSE;
	SLD;
	SRD;
	<>I;
	LN;
	LAR1;
	XN FALSE;
	ZR Z 42;
	L 0;
	CLR;
	SPN AASK;
AASK:	NOP 0;
	ON M 0.4;
	UW;
	+AR1;
	LEAVE;
	TAD;
	L 0;
	CLR;
	LOOP AASL;
AASL:	NOP 0;
	L 0;
	SS T 42;
	L 0;
	SA T 42;
	SAVE;
	ACOS;
	L DW#16#7B5FBE41;
	-R;
	<=D;
	POP;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	UN(;
	);
	O M 0.4;
	<>R;
	L 0;
	SI T 42;
	SSD;
	RRD;
	<R;
	R M 0.4;
	RLD;
	L 0;
	CLR;
	SPM AASM;
AASM:	NOP 0;
	RND-;
	L 0;
	CLR;
	SPMZ AASN;
AASN:	NOP 0;
	L 0;
	CLR;
	SPB AASO;
AASO:	NOP 0;
	U(;
	);
	L 0;
	SI T 42;
	TAD;
	TAK;
	MOD;
	SQRT;
	RND+;
	S M 0.4;
	TAR2;
	LAR2;
	DEC 0;
	T MD 0;
	SET;
	RLDA;
	T MD 0;
	L 0;
	CLR;
	SPN AASP;
AASP:	NOP 0;
	<I;
	RLDA;
	X M 0.4;
	FP M 0.4;
	SQRT;
	LN;
	ON FALSE;
	CLR;
	CC FC 43;
	L 0;
	CLR;
	SPO AASQ;
AASQ:	NOP 0;
	L 0;
	SV T 42;
	ENT;
	INVD;
	TAR1;
	+I;
	-D;
	UN(;
	);
	TAD;
	TAR1;
	L 0;
	CLR;
	SPMZ AASR;
AASR:	NOP 0;
	ENT;
	SET;
	SLW;
	-D;
	TAR;
	>I;
	SAVE;
	TAW;
	U M 0.4;
	+I;
	/I;
	L 0;
	CLR;
	SPBNB AASS;
AASS:	NOP 0;
	TAK;
	L 0;
	SA T 42;
	/D;
	==I;
	XN FALSE;
	RRD;
	>D;
	EXP;
	==I;
	ZV Z 42;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	DTR;
	ITD;
	<I;
	/R;
	NEGR;
	TAR2;
	ITD;
	L 0;
	CLR;
	LOOP AAST;
AAST:	NOP 0;
	==I;
	SIN;
	XN FALSE;
	TAR;
	TAR2;
	NOP 0;
	L 0;
	SI T 42;
	<>D;
	RLDA;
	UN M 0.4;
	OW;
	U(;
	);
	PUSH;
	ACOS;
	BLD 0;
	SLD;
	L 0;
	SV T 42;
	L 0;
	BTI;
	+AR2;
	<=R;
	<=I;
	FP M 0.4;
	*R;
	SET;
	UC FC 44;
	L 0;
	CLR;
	SPM AASU;
AASU:	NOP 0;
	L 0;
	SI T 42;
	-R;
	COS;
	UC FC 44;
	L DW#16#460A6125;
	+I;
	L 0;
	CLR;
	SPBI AASV;
AASV:	NOP 0;
	TAR;
	<>D;
	>D;
	LN;
	CC FC 43;
	L 0;
	SE T 42;
	L 0;
	CLR;
	SPBIN AASW;
AASW:	NOP 0;
	TAK;
	L 0;
	CLR;
	SPN AASX;
AASX:	NOP 0;
	PUSH;
	NEGR;
	INVI;
	NEGI;
	L 0;
	CLR;
	SPBNB AASY;
AASY:	NOP 0;
	-I;
	==D;
	L 0;
	BTI;
	RRDA;
	OD;
	L 0;
	CLR;
	SPM AASZ;
AASZ:	NOP 0;
	>I;
	/I;
	ENT;
	SRW;
	BLD 0;
	DEC 0;
	SIN;
	XOW;
	L 0;
	CLR;
	SPBB AATA;
AATA:	NOP 0;
	TAN;
	ON M 0.4;
	L 0;
	SA T 42;
	==I;
	U TRUE;
	>=D;
	UN(;
	);
	O(;
	);
	INVI;
	TDB;
	>R;
	L 0;
	CLR;
	SPBB AATB;
AATB:	NOP 0;
	LC MW 0;
	>=D;
	ON(;
	);
	L 0;
	CLR;
	SPBI AATC;
AATC:	NOP 0;
	INVD;
	OD;
	O TRUE;
	TAR;
	FP M 0.4;
	ENT;
	TAD;
	ENT;
	*R;
	RND+;
	L 0;
	SV T 42;
	L 0;
	CLR;
	SPBB AATD;
AATD:	NOP 0;
	U(;
	);
	+R;
	*R;
	SIN;
	L 0;
	CLR;
	SPN AATE;
AATE:	NOP 0;
	PUSH;
	UN(;
	);
	ON M 0.4;
	LC MW 0;
	INVI;
	LAR2;
	TAD;
	*D;
	NOP 0;
	XOD;
	CC FC 43;
	DTR;
	DTB;
	L 0;
	CLR;
	SPBI AATF;
AATF:	NOP 0;
	T MD 0;
	L 0;
	BTI;
	R M 0.4;
	L 0;
	BTD;
	<=R;
	L 0;
	SE T 42;
	<I;
	MOD;
	X TRUE;
	L 0;
	CLR;
	SPB AATG;
AATG:	NOP 0;
	POP;
	AUF DB 42;
	==D;
	>R;
	BLD 0;
	ZV Z 42;
	UN M 0.4;
	L 0;
	CLR;
	SPMZ AATH;
AATH:	NOP 0;
	SSI;
	==R;
	X FALSE;
	L 0;
	CLR;
	SPM AATI;
AATI:	NOP 0;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	UN(;
	);
	L 0;
	CLR;
	SPO AATJ;
AATJ:	NOP 0;
	RLD;
	DEC 0;
	TAK;
	+ 0;
	= M 0.4;
	L 0;
	CLR;
	SPP AATK;
AATK:	NOP 0;
	UW;
	TAW;
	L 0;
	BTD;
	L 0;
	SA T 42;
	XN(;
	);
	L 0;
	SI T 42;
	<>R;
	SIN;
	XOD;
	UD;
	SQRT;
	CLR;
	*I;
	TAW;
	NEGD;
	L 0;
	CLR;
	SPMZ AATL;
AATL:	NOP 0;
	L 0;
	CLR;
	SPMZ AATM;
AATM:	NOP 0;
	+D;
	L 0;
	CLR;
	SPBI AATN;
AATN:	NOP 0;
	NEGR;
	OW;
	SLW;
	ENT;
	O M 0.4;
	>I;
	-I;
	T MD 0;
	RND-;
	FR Z 42;
	X TRUE;
	+R;
	>I;
	-R;
	ZV Z 42;
	OD;
	L 0;
	CLR;
	SPBN AATO;
AATO:	NOP 0;
	U TRUE;
	L 0;
	SE T 42;
	L 0;
	SV T 42;
	T MD 0;
	SRD;
	XN TRUE;
	DTB;
	L 0;
	CLR;
	SPM AATP;
AATP:	NOP 0;
	L 0;
	SE T 42;
	NOT;
	SAVE;
	<R;
	UD;
	XOW;
	UN M 0.4;
	X(;
	);
	NEGI;
	NEGD;
	TAN;
	FP M 0.4;
	INVD;
	UD;
	ATAN;
	= M 0.4;
	==R;
	U TRUE;
	L 0;
	CLR;
	SPMZ AATQ;
AATQ:	NOP 0;
	ON FALSE;
	= M 0.4;
	UN(;
	);
	L 0;
	BTI;
	LC MW 0;
	POP;
	= M 0.4;
	+AR1;
	RND;
	ZR Z 42;
	EXP;
	*R;
	TAR;
	SQRT;
	ACOS;
	L 0;
	CLR;
	SPN AATR;
AATR:	NOP 0;
	X M 0.4;
	*R;
	<I;
	XOW;
	UN M 0.4;
	X(;
	);
	BLD 0;
	XN FALSE;
	+ 0;
	RRDA;
	==I;
	L 0;
	CLR;
	SPBNB AATS;
AATS:	NOP 0;
	L 0;
	CLR;
	SPO AATT;
AATT:	NOP 0;
	UC FC 44;
	SET;
	L 0;
	CLR;
	SPBN AATU;
AATU:	NOP 0;
	LAR1;
	+R;
	ABS;
	UN TRUE;
	<>R;
	XOW;
	TAW;
	<>D;
	/R;
	XOD;
	L 0;
	CLR;
	SPBI AATV;
AATV:	NOP 0;
	<D;
	L 0;
	CLR;
	SPBIN AATW;
AATW:	NOP 0;
	/D;
	O M 0.4;
	PUSH;
	POP;
	<D;
	>=I;
	X FALSE;
	DEC 0;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	/R;
	UD;
	TAK;
	NOT;
	L 0;
	CLR;
	SPS AATX;
AATX:	NOP 0;
	NEGI;
	-I;
	NEGD;
	LN;
	L 0;
	SE T 42;
	<D;
	>R;
	L 0;
	BTD;
	TAW;
	LC MW 0;
	DTB;
	>I;
	ITB;
	INC 0;
	UN(;
	);
	TAK;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	TAK;
	= M 0.4;
	L 0;
	CLR;
	SPBNB AATY;
AATY:	NOP 0;
	XN(;
	);
	LC MW 0;
	FN M 0.4;
	DTR;
	+AR2;
	SRD;
	L 0;
	CLR;
	SPMZ AATZ;
AATZ:	NOP 0;
	+ 0;
	<=I;
	RND+;
	FN M 0.4;
	L 0;
	CLR;
	SPBN AAUA;
AAUA:	NOP 0;
	XN(;
	);
	DTB;
	L 0;
	CLR;
	SPP AAUB;
AAUB:	NOP 0;
	SRD;
	TAR;
	L 0;
	CLR;
	SPMZ AAUC;
AAUC:	NOP 0;
	L 0;
	CLR;
	SPS AAUD;
AAUD:	NOP 0;
	BLD 0;
	==R;
	LEAVE;
	INC 0;
	-D;
	L 0;
	CLR;
	SPN AAUE;
AAUE:	NOP 0;
	ASIN;
	>=R;
	UN M 0.4;
	L 0;
	CLR;
	SPN AAUF;
AAUF:	NOP 0;
	L DW#16#C921057C;
	ATAN;
	L 0;
	L 0;
	CLR;
	SPL AAUG;
AAUG:	NOP 0;
	+D;
	<>D;
	L 0;
	CLR;
	SPMZ AAUH;
AAUH:	NOP 0;
	SRW;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	T MD 0;
	+ 0;
	L 0;
	CLR;
	SPS AAUI;
AAUI:	NOP 0;
	SRD;
	PUSH;
	==I;
	<=R;
	UC FC 44;
	S M 0.4;
	L 0;
	CLR;
	SPB AAUJ;
AAUJ:	NOP 0;
	>D;
	UD;
	DTR;
	AUF DB 42;
	R M 0.4;
	R M 0.4;
	X M 0.4;
	L 0;
	SI T 42;
	UN TRUE;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	NEGD;
	ON TRUE;
	XOD;
	OD;
	SSD;
	<=D;
	-D;
	/R;
	TAD;
	NOP 0;
	L 0;
	CLR;
	SPBNB AAUK;
AAUK:	NOP 0;
	<>D;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	RRDA;
	L 0;
	SV T 42;
	CLR;
	ABS;
	-D;
	RRDA;
	O M 0.4;
	RND-;
	<R;
	L 0;
	SE T 42;
	>D;
	T MD 0;
	<>R;
	L 0;
	BTI;
	LEAVE;
	LEAVE;
	>=D;
	SLD;
	+ 0;
	X FALSE;
	SRD;
	TRUNC;
	X(;
	);
	AUF DB 42;
	*D;
	TRUNC;
	X FALSE;
	L 0;
	SS T 42;
	+D;
	*R;
	SSD;
	TAR1;
	XN FALSE;
	L 0;
	CLR;
	SPM AAUL;
AAUL:	NOP 0;
	FP M 0.4;
	L 0;
	SA T 42;
	L 0;
	L 0;
	CLR;
	SPL AAUM;
AAUM:	NOP 0;
	AUF DB 42;
	+AR2;
	XOD;
	INC 0;
	<=R;
	MOD;
	MOD;
	-D;
	NOP 0;
	R M 0.4;
	L 0;
	SS T 42;
	LC MW 0;
	MOD;
	TAD;
	L 0;
	SS T 42;
	SQRT;
	/I;
	-I;
	SRD;
	SLD;
	CC FC 43;
	UN M 0.4;
	RRDA;
	>D;
	LAR1;
	<R;
	RND;
	R M 0.4;
	L 0;
	SE T 42;
	L 0;
	CLR;
	SPB AAUN;
AAUN:	NOP 0;
	NEGD;
	<=D;
	L 0;
	BTD;
	<>R;
	+D;
	CC FC 43;
	<I;
	RND;
	SIN;
	L 0;
	CLR;
	SPMZ AAUO;
AAUO:	NOP 0;
	>I;
	SLD;
	SRW;
	SRW;
	NEGI;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	>R;
	LN;
	XN M 0.4;
	FR Z 42;
	XN FALSE;
	DEC 0;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	>R;
	<>D;
	L 0;
	SE T 42;
	X FALSE;
	O(;
	);
	<R;
	ZR Z 42;
	ITB;
	L 0;
	SS T 42;
	SQRT;
	SET;
	LEAVE;
	X M 0.4;
	L 0;
	CLR;
	SPBN AAUP;
AAUP:	NOP 0;
	NOT;
	NEGR;
	T MD 0;
	UC FC 44;
	SSD;
	SLD;
	>=R;
	TAW;
	LN;
	SET;
	<D;
	BLD 0;
	ITB;
	L 0;
	SV T 42;
	AUF DB 42;
	<R;
	+I;
	TAR1;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	XN(;
	);
	RND;
	MOD;
	-R;
	==D;
	==I;
	X M 0.4;
	INVI;
	L 0;
	SA T 42;
	L 0;
	SI T 42;
	COS;
	<=D;
	UC FC 44;
	SAVE;
	L 0;
	BTI;
	SLW;
	SET;
	ON FALSE;
	CLR;
	SLD;
	==D;
	CC FC 43;
	OD;
	U M 0.4;
	ACOS;
	L 0;
	SA T 42;
	COS;
	*D;
	XN TRUE;
	RND;
	SLD;
	+R;
	*I;
	NOP 0;
	+AR1;
	FN M 0.4;
	TAN;
	<>D;
	ZV Z 42;
	SRW;
	TRUNC;
	NOT;
	L 0;
	CLR;
	SPBN AAUQ;
AAUQ:	NOP 0;
	SET;
	XOD;
	EXP;
	ZV Z 42;
	ITD;
	UN M 0.4;
	UN M 0.4;
	+AR1;
	L 0;
	SA T 42;
	<I;
	L 0;
	SA T 42;
	UN M 0.4;
	MOD;
	INVD;
	L 0;
	CLR;
	SPN AAUR;
AAUR:	NOP 0;
	EXP;
	+D;
	==I;
	==R;
	ASIN;
	BLD 0;
	LC MW 0;
	ZR Z 42;
	UD;
	TAN;
	LEAVE;
	-D;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	L 0;
	L 0;
	CLR;
	SPL AAUS;
AAUS:	NOP 0;
	ABS;
	INVD;
	LN;
	PUSH;
	POP;
	SLD;
	L 0;
	BTI;
	*D;
	ENT;
	POP;
	SLD;
	LC MW 0;
	L 0;
	CLR;
	SPS AAUT;
AAUT:	NOP 0;
	+AR1;
	-I;
	ABS;
	>D;
	<I;
	RND;
	T MD 0;
	>R;
	FN M 0.4;
	NEGD;
	L 0;
	SV T 42;
	SQR;
	L 0;
	CLR;
	LOOP AAUU;
AAUU:	NOP 0;
	TAK;
	UN(;
	);
	>R;
	*R;
	UN M 0.4;
	CLR;
	>=D;
	SSD;
	SET;
	ATAN;
	SET;
	X(;
	);
	AUF DB 42;
	TAW;
	*D;
	S M 0.4;
	UC FC 44;
	ON TRUE;
	SQR;
	L 0;
	SA T 42;
	L 0;
	CLR;
	SPBB AAUV;
AAUV:	NOP 0;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	O(;
	);
	<=R;
	RRD;
	LAR1;
	O M 0.4;
	INVI;
	L 0;
	SS T 42;
	L 0;
	CLR;
	SPBB AAUW;
AAUW:	NOP 0;
	DTB;
	O FALSE;
	>=R;
	ON TRUE;
	RND-;
	U M 0.4;
	<>R;
	SET;
	L 0;
	L 0;
	CLR;
	SPL AAUX;
AAUX:	NOP 0;
	SQR;
	/I;
	ABS;
	SQRT;
	NOP 0;
	INVI;
	L 0;
	SS T 42;
	ON M 0.4;
	XN(;
	);
	CLR;
	TAK;
	L 0;
	CLR;
	SPBN AAUY;
AAUY:	NOP 0;
	ENT;
	BLD 0;
	*I;
	-I;
	L 0;
	L 0;
	CLR;
	SPL AAUZ;
AAUZ:	NOP 0;
	TAD;
	UC FC 44;
	DTB;
	TAR1;
	SQRT;
	+AR1;
	UN M 0.4;
	ZR Z 42;
	<=R;
	EXP;
	L 0;
	SI T 42;
	==I;
	ENT;
	= M 0.4;
	RRDA;
	L 0;
	CLR;
	SPBI AAVA;
AAVA:	NOP 0;
	+I;
	>I;
	L 0;
	SE T 42;
	ZV Z 42;
	UD;
	+AR1;
	LC MW 0;
	LAR2;
	MOD;
	LEAVE;
	SLD;
	FR Z 42;
	L 0;
	CLR;
	LOOP AAVB;
AAVB:	NOP 0;
	TAR2;
	TAR2;
	NOP 0;
	UN TRUE;
	>I;
	ZR Z 42;
	XN(;
	);
	+R;
	TAW;
	RND;
	L 0;
	CLR;
	SPN AAVC;
AAVC:	NOP 0;
	LN;
	/I;
	L 0;
	SS T 42;
	UD;
	O M 0.4;
	AUF DB 42;
	L DW#16#498BCF67;
	SQR;
	+I;
	R M 0.4;
	PUSH;
	L 0;
	BTI;
	SLW;
	L 0;
	CLR;
	SPN AAVD;
AAVD:	NOP 0;
	/I;
	NEGR;
	DEC 0;
	TDB;
	ITB;
	ITD;
	RLDA;
	INVI;
	RND+;
	RND-;
	AUF DB 42;
	INVD;
	RND;
	INVI;
	L DW#16#5B249C2A;
	==I;
	<I;
	S M 0.4;
	RRD;
	UN M 0.4;
	OD;
	X TRUE;
	/D;
	L 0;
	CLR;
	SPN AAVE;
AAVE:	NOP 0;
	RRD;
	+AR1;
	L 0;
	L 0;
	CLR;
	SPL AAVF;
AAVF:	NOP 0;
	RLD;
	ITB;
	L 0;
	SV T 42;
	L 0;
	CLR;
	SPB AAVG;
AAVG:	NOP 0;
	ABS;
	TAW;
	+AR1;
	<=I;
	UN(;
	);
	UW;
	TAN;
	SRW;
	OD;
	O TRUE;
	/R;
	<=R;
	TAR2;
	<I;
	L 0;
	SS T 42;
	TAR2;
	L 0;
	CLR;
	SPN AAVH;
AAVH:	NOP 0;
	O M 0.4;
	ON M 0.4;
	NEGI;
	+R;
	+AR2;
	FN M 0.4;
	L 0;
	CLR;
	SPPZ AAVI;
AAVI:	NOP 0;
	+D;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	ZR Z 42;
	L 0;
	BTD;
	TAK;
	AUF DB 42;
	RND+;
	TDB;
	SSD;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	+I;
	-D;
	L 0;
	BTD;
	RLDA;
	TAN;
	NEGI;
	COS;
	/D;
	-D;
	SQR;
	L 0;
	CLR;
	SPB AAVJ;
AAVJ:	NOP 0;
	TAR;
	ITB;
	DEC 0;
	==D;
	+AR1;
	RND;
	FN M 0.4;
	L 0;
	CLR;
	SPA AAVK;
AAVK:	NOP 0;
	RND+;
	POP;
	ACOS;
	+R;
	DTR;
	>=D;
	<=D;
	SLW;
	O M 0.4;
	L 0;
	BTI;
	COS;
	RLDA;
	<>D;
	L 0;
	SS T 42;
	XOW;
	L 0;
	CLR;
	SPN AAVL;
AAVL:	NOP 0;
	SRD;
	L 0;
	CLR;
	SPBIN AAVM;
AAVM:	NOP 0;
	LC MW 0;
	ENT;
	INC 0;
	U(;
	);
	ABS;
	FN M 0.4;
	>R;
	ON(;
	);
	NEGR;
	ZV Z 42;
	SLW;
	SAVE;
	TAR;
	L 0;
	CLR;
	SPU AAVN;
AAVN:	NOP 0;
	ZR Z 42;
	+D;
	+D;
	ENT;
	POP;
	ZV Z 42;
	-I;
	XN M 0.4;
	LN;
	>=I;
	*I;
	UC FC 44;
	DTR;
	+AR1;
	+AR1;
	UD;
	<=R;
	L 0;
	CLR;
	SPBN AAVO;
AAVO:	NOP 0;
	/I;
	L 0;
	CLR;
	SPPZ AAVP;
AAVP:	NOP 0;
	L 0;
	SV T 42;
	SRD;
	T MD 0;
	S M 0.4;
	+R;
	L 0;
	CLR;
	SPBB AAVQ;
AAVQ:	NOP 0;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	>=D;
	<R;
	L 0;
	CLR;
	LOOP AAVR;
AAVR:	NOP 0;
	COS;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	DEC 0;
	SQRT;
	= M 0.4;
	S M 0.4;
	>R;
	+I;
	RND;
	L 0;
	CLR;
	SPN AAVS;
AAVS:	NOP 0;
	L 0;
	CLR;
	SPP AAVT;
AAVT:	NOP 0;
	L 0;
	CLR;
	SPBNB AAVU;
AAVU:	NOP 0;
	TDB;
	CC FC 43;
	ABS;
	L 0;
	CLR;
	SPA AAVV;
AAVV:	NOP 0;
	LAR2;
	+D;
	NOP 0;
	L 0;
	SA T 42;
	TAR;
	LN;
	<R;
	L 0;
	BTD;
	XN M 0.4;
	<=I;
	RND+;
	LC MW 0;
	S M 0.4;
	NEGI;
	<R;
	ABS;
	FP M 0.4;
	SAVE;
	X(;
	);
	SLW;
	TAK;
	UN(;
	);
	U TRUE;
	UW;
	NOT;
	FP M 0.4;
	AUF DB 42;
	==R;
	NOT;
	*R;
	L 0;
	CLR;
	SPZ AAVW;
AAVW:	NOP 0;
	RND;
	L DW#16#BCD2E8EB;
	LAR2;
	<=I;
	==D;
	UW;
	>=R;
	UN FALSE;
	+ 0;
	L 0;
	CLR;
	SPPZ AAVX;
AAVX:	NOP 0;
	SLW;
	SSI;
	OD;
	L 0;
	CLR;
	SPA AAVY;
AAVY:	NOP 0;
	TAK;
	LAR2;
	<>D;
	OD;
	L 0;
	BTI;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	TAR1;
	LEAVE;
	ATAN;
	UW;
	XOW;
	L 0;
	CLR;
	SPZ AAVZ;
AAVZ:	NOP 0;
	-I;
	SLD;
	OD;
	RND;
	SET;
	LAR2;
	L 0;
	CLR;
	SPS AAWA;
AAWA:	NOP 0;
	-D;
	LN;
	ZR Z 42;
	==R;
	L 0;
	CLR;
	SPO AAWB;
AAWB:	NOP 0;
	O M 0.4;
	U M 0.4;
	L 0;
	SA T 42;
	<>D;
	-I;
	L 0;
	CLR;
	SPBB AAWC;
AAWC:	NOP 0;
	SSD;
	XOW;
	O M 0.4;
	RLD;
	SRW;
	L 0;
	CLR;
	SPBIN AAWD;
AAWD:	NOP 0;
	O M 0.4;
	ACOS;
	L 0;
	CLR;
	SPBNB AAWE;
AAWE:	NOP 0;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	TRUNC;
	UN M 0.4;
	TAK;
	/D;
	ITD;
	LN;
	ENT;
	ATAN;
	ABS;
	L DW#16#60DC12EB;
	AUF DB 42;
	S M 0.4;
	TAN;
	RND-;
	L 0;
	SS T 42;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	L 0;
	CLR;
	SPA AAWF;
AAWF:	NOP 0;
	L 0;
	CLR;
	SPBN AAWG;
AAWG:	NOP 0;
	XOW;
	TDB;
	LN;
	ITD;
	XN(;
	);
	ITB;
	<>D;
	L 0;
	CLR;
	SPBNB AAWH;
AAWH:	NOP 0;
	<>I;
	TAR1;
	TAR;
	L 0;
	CLR;
	SPA AAWI;
AAWI:	NOP 0;
	RLD;
	ITD;
	L 0;
	CLR;
	SPM AAWJ;
AAWJ:	NOP 0;
	X M 0.4;
	<=D;
	U(;
	);
	XOW;
	XN M 0.4;
	L 0;
	BTD;
	FP M 0.4;
	L 0;
	CLR;
	SPBN AAWK;
AAWK:	NOP 0;
	TDB;
	<=I;
	LAR1;
	O M 0.4;
	TRUNC;
	CLR;
	<=D;
	ON M 0.4;
	RRD;
	NEGR;
	+I;
	COS;
	L 0;
	CLR;
	SPZ AAWL;
AAWL:	NOP 0;
	RLDA;
	/D;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	O TRUE;
	S M 0.4;
	>=D;
	O(;
	);
	TDB;
	/R;
	= M 0.4;
	XOD;
	SSD;
	ITB;
	DTB;
	LC MW 0;
	+R;
	ON M 0.4;
	>=I;
	L DW#16#F997C779;
	L DW#16#08942176;
	TAR2;
	SAVE;
	L 0;
	SA T 42;
	NEGI;
	SLW;
	*R;
	L 0;
	CLR;
	SPZ AAWM;
AAWM:	NOP 0;
	L 0;
	CLR;
	SPM AAWN;
AAWN:	NOP 0;
	<>R;
	X FALSE;
	LC MW 0;
	SLD;
	L 0;
	CLR;
	SPBIN AAWO;
AAWO:	NOP 0;
	DTR;
	+D;
	UN(;
	);
	NEGR;
	<>I;
	RND+;
	ATAN;
	L 0;
	CLR;
	SPPZ AAWP;
AAWP:	NOP 0;
	ON M 0.4;
	<R;
	L 0;
	L 0;
	CLR;
	SPL AAWQ;
AAWQ:	NOP 0;
	BLD 0;
	<I;
	ABS;
	FR Z 42;
	O M 0.4;
	X TRUE;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	==R;
	/D;
	SET;
	L DW#16#285EED0A;
	CLR;
	L 0;
	CLR;
	LOOP AAWR;
AAWR:	NOP 0;
	ON(;
	);
	ON(;
	);
	+ 0;
	==R;
	UD;
	==I;
	<=I;
	SRD;
	TRUNC;
	L 0;
	CLR;
	SPP AAWS;
AAWS:	NOP 0;
	POP;
	-I;
	LAR1;
	DTB;
	XN M 0.4;
	MOD;
	+ 0;
	<>D;
	LC MW 0;
	X TRUE;
	LAR1;
	ENT;
	L 0;
	CLR;
	SPBI AAWT;
AAWT:	NOP 0;
	OD;
	RLD;
	ITD;
	INC 0;
	L 0;
	BTD;
	XOD;
	*I;
	L 0;
	CLR;
	SPM AAWU;
AAWU:	NOP 0;
	SSI;
	L 0;
	L 0;
	CLR;
	SPL AAWV;
AAWV:	NOP 0;
	SET;
	PUSH;
	>R;
	XN(;
	);
	OW;
	==R;
	TAR;
	L 0;
	CLR;
	SPBI AAWW;
AAWW:	NOP 0;
	AUF DB 42;
	OD;
	-D;
	TAR1;
	U M 0.4;
	L 0;
	SI T 42;
	+R;
	L 0;
	BTD;
	X M 0.4;
	-D;
	RND-;
	L 0;
	CLR;
	SPM AAWX;
AAWX:	NOP 0;
	X(;
	);
	UD;
	*R;
	ITD;
	UW;
	RLDA;
	PUSH;
	==R;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	L 0;
	CLR;
	SPBN AAWY;
AAWY:	NOP 0;
	L 0;
	CLR;
	SPM AAWZ;
AAWZ:	NOP 0;
	EXP;
	L 0;
	CLR;
	SPM AAXA;
AAXA:	NOP 0;
	<>I;
	SAVE;
	L 0;
	SA T 42;
	XN(;
	);
	XN FALSE;
	L 0;
	BTI;
	O FALSE;
	==I;
	SRD;
	DTB;
	FN M 0.4;
	O TRUE;
	RLD;
	UW;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	ZV Z 42;
	U(;
	);
	-D;
	TAW;
	UC FC 44;
	= M 0.4;
	ON M 0.4;
	NEGI;
	RLD;
	S M 0.4;
	SSI;
	ON(;
	);
	+D;
	POP;
	SIN;
	*D;
	O(;
	);
	TDB;
	OW;
	X FALSE;
	L 0;
	CLR;
	SPO AAXB;
AAXB:	NOP 0;
	R M 0.4;
	NEGR;
	L 0;
	SS T 42;
	SAVE;
	FN M 0.4;
	TRUNC;
	XOW;
	-R;
	ITD;
	DTB;
	UW;
	L DW#16#F28F9444;
	POP;
	POP;
	SIN;
	==I;
	+AR1;
	+ 0;
	TAR2;
	ASIN;
	FP M 0.4;
	<R;
	ITB;
	TAK;
	SQR;
	L 0;
	SI T 42;
	L 0;
	CLR;
	LOOP AAXC;
AAXC:	NOP 0;
	<>R;
	XOW;
	SET;
	LAR2;
	/I;
	L 0;
	CLR;
	SPN AAXD;
AAXD:	NOP 0;
	TAK;
	L 0;
	CLR;
	SPPZ AAXE;
AAXE:	NOP 0;
	/D;
	LN;
	ACOS;
	L 0;
	CLR;
	SPM AAXF;
AAXF:	NOP 0;
	UC FC 44;
	RND-;
	LEAVE;
	XOD;
	NEGD;
	MOD;
	TAK;
	ZV Z 42;
	+D;
	TAR;
	T MD 0;
	ABS;
	U M 0.4;
	O TRUE;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	X M 0.4;
	L 0;
	SS T 42;
	<>D;
	L 0;
	CLR;
	SPO AAXG;
AAXG:	NOP 0;
	UN M 0.4;
	L 0;
	CLR;
	SPBIN AAXH;
AAXH:	NOP 0;
	TAW;
	NEGD;
	L 0;
	CLR;
	SPN AAXI;
AAXI:	NOP 0;
	XN M 0.4;
	L 0;
	L 0;
	CLR;
	SPL AAXJ;
AAXJ:	NOP 0;
	PUSH;
	L 0;
	SV T 42;
	POP;
	DEC 0;
	DEC 0;
	==R;
	SAVE;
	ON TRUE;
	+ 0;
	==R;
	>D;
	AUF DB 42;
	-D;
	BLD 0;
	L DW#16#3BA58126;
	L 0;
	CLR;
	SPBIN AAXK;
AAXK:	NOP 0;
	CLR;
	DEC 0;
	SQR;
	INC 0;
	NEGR;
	R M 0.4;
	L 0;
	CLR;
	SPPZ AAXL;
AAXL:	NOP 0;
	SLD;
	<=R;
	SRD;
	+AR1;
	SAVE;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	L 0;
	CLR;
	SPBIN AAXM;
AAXM:	NOP 0;
	ON TRUE;
	S M 0.4;
	O(;
	);
	L 0;
	CLR;
	SPU AAXN;
AAXN:	NOP 0;
	*I;
	ATAN;
	SIN;
	<I;
	RND;
	CC FC 43;
	O M 0.4;
	+R;
	UN(;
	);
	L 0;
	CLR;
	SPS AAXO;
AAXO:	NOP 0;
	UW;
	X TRUE;
	OD;
	LEAVE;
	<=D;
	L 0;
	CLR;
	SPPZ AAXP;
AAXP:	NOP 0;
	RRDA;
	TAW;
	==R;
	U(;
	);
	/R;
	T MD 0;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	+AR1;
	L 0;
	SI T 42;
	CLR;
	TAW;
	ACOS;
	L 0;
	CLR;
	SPBNB AAXQ;
AAXQ:	NOP 0;
	/R;
	>=D;
	==D;
	L 0;
	CLR;
	LOOP AAXR;
AAXR:	NOP 0;
	NOT;
	SLW;
	DEC 0;
	U(;
	);
	TAK;
	SQR;
	AUF DB 42;
	NOT;
	SQR;
	RRDA;
	ATAN;
	==D;
	<>D;
	SLD;
	ENT;
	DTR;
	SRD;
	ABS;
	DEC 0;
	DTR;
	ENT;
	UW;
	L DW#16#3E085CB7;
	TDB;
	ACOS;
	L 0;
	CLR;
	SPM AAXS;
AAXS:	NOP 0;
	+AR1;
	SET;
	<>I;
	LN;
	TAN;
	-D;
	*I;
	ITD;
	L 0;
	CLR;
	SPM AAXT;
AAXT:	NOP 0;
	-I;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	U TRUE;
	>=R;
	*I;
	LAR2;
	>=D;
	LAR1;
	XN FALSE;
	INVI;
	/D;
	==R;
	NOT;
	<>I;
	UN(;
	);
	FR Z 42;
	>=D;
	L 0;
	CLR;
	SPBB AAXU;
AAXU:	NOP 0;
	ON M 0.4;
	+I;
	<>I;
	L 0;
	CLR;
	SPS AAXV;
AAXV:	NOP 0;
	TAR;
	SSD;
	XN M 0.4;
	L 0;
	CLR;
	SPMZ AAXW;
AAXW:	NOP 0;
	NEGI;
	UD;
	NEGD;
	INVD;
	XOD;
	L 0;
	SA T 42;
	ZR Z 42;
	TAK;
	SLD;
	<D;
	X M 0.4;
	MOD;
	BLD 0;
	UW;
	XN TRUE;
	>=R;
	ON(;
	);
	L 0;
	CLR;
	SPBN AAXX;
AAXX:	NOP 0;
	INVI;
	L 0;
	CLR;
	SPA AAXY;
AAXY:	NOP 0;
	UN(;
	);
	SSI;
	O M 0.4;
	XN(;
	);
	*R;
	L 0;
	CLR;
	SPA AAXZ;
AAXZ:	NOP 0;
	+D;
	==I;
	X M 0.4;
	L 0;
	CLR;
	SPBNB AAYA;
AAYA:	NOP 0;
	-R;
	TRUNC;
	+R;
	L 0;
	SV T 42;
	FN M 0.4;
	L 0;
	CLR;
	SPN AAYB;
AAYB:	NOP 0;
	SRD;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	XOW;
	SET;
	L 0;
	BTD;
	DTR;
	RRDA;
	TAR2;
	ENT;
	XN M 0.4;
	X FALSE;
	OW;
	L 0;
	CLR;
	SPS AAYC;
AAYC:	NOP 0;
	L 0;
	CLR;
	SPU AAYD;
AAYD:	NOP 0;
	RLD;
	/R;
	<>R;
	X M 0.4;
	-I;
	/I;
	/I;
	L 0;
	CLR;
	SPO AAYE;
AAYE:	NOP 0;
	RND+;
	RRDA;
	L 0;
	L 0;
	CLR;
	SPL AAYF;
AAYF:	NOP 0;
	ON(;
	);
	ZV Z 42;
	*R;
	UN TRUE;
	TAD;
	<=D;
	+I;
	/R;
	>D;
	SET;
	+R;
	L 0;
	SA T 42;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	RND;
	SIN;
	RND-;
	DEC 0;
	==R;
	ASIN;
	L 0;
	CLR;
	SPZ AAYG;
AAYG:	NOP 0;
	CC FC 43;
	L 0;
	CLR;
	SPMZ AAYH;
AAYH:	NOP 0;
	T MD 0;
	OD;
	==D;
	INVD;
	>D;
	+AR2;
	OD;
	INVI;
	>D;
	L 0;
	CLR;
	SPZ AAYI;
AAYI:	NOP 0;
	UW;
	<>D;
	ACOS;
	>=D;
	LEAVE;
	<>R;
	L 0;
	CLR;
	SPP AAYJ;
AAYJ:	NOP 0;
	XN(;
	);
	POP;
	XOW;
	<I;
	L 0;
	BTD;
	L 0;
	CLR;
	SPP AAYK;
AAYK:	NOP 0;
	>=D;
	UN TRUE;
	LN;
	LN;
	L 0;
	CLR;
	SPO AAYL;
AAYL:	NOP 0;
	LAR2;
	L 0;
	L 0;
	CLR;
	SPL AAYM;
AAYM:	NOP 0;
	<=D;
	ITD;
	==I;
	==D;
	L 0;
	BTD;
	U TRUE;
	UC FC 44;
	INC 0;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	TRUNC;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	TRUNC;
	TRUNC;
	U TRUE;
	S M 0.4;
	SRW;
	<>D;
	RRDA;
	CC FC 43;
	SSD;
	/D;
	L 0;
	BTD;
	*R;
	RLD;
	SLW;
	>D;
	>R;
	DTB;
	TAD;
	O TRUE;
	ON M 0.4;
	L 0;
	CLR;
	SPA AAYN;
AAYN:	NOP 0;
	LN;
	TAW;
	INVI;
	INVD;
	X(;
	);
	L 0;
	BTI;
	LAR1;
	RLD;
	L 0;
	CLR;
	SPPZ AAYO;
AAYO:	NOP 0;
	TAR2;
	L DW#16#6D744A0B;
	X TRUE;
	L 0;
	CLR;
	SPN AAYP;
AAYP:	NOP 0;
	/R;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	DEC 0;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	UD;
	UW;
	ON FALSE;
	TAR;
	TAR1;
	X FALSE;
	L 0;
	SS T 42;
	UD;
	ABS;
	X TRUE;
	L 0;
	SS T 42;
	U(;
	);
	ITD;
	L 0;
	CLR;
	SPBNB AAYQ;
AAYQ:	NOP 0;
	LAR1;
	ABS;
	L 0;
	CLR;
	SPO AAYR;
AAYR:	NOP 0;
	L 0;
	CLR;
	SPBB AAYS;
AAYS:	NOP 0;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	<R;
	TAN;
	L 0;
	CLR;
	SPBI AAYT;
AAYT:	NOP 0;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	UN(;
	);
	L 0;
	SS T 42;
	<D;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	TAR;
	CLR;
	RRDA;
	<>I;
	ITB;
	BLD 0;
	XOD;
	<>D;
	/R;
	LN;
	L 0;
	CLR;
	SPM AAYU;
AAYU:	NOP 0;
	TAR;
	U FALSE;
	TAR1;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	INVI;
	TAR1;
	CLR;
	LC MW 0;
	L 0;
	CLR;
	SPM AAYV;
AAYV:	NOP 0;
	>R;
	>=I;
	CLR;
	>I;
	TAR;
	+D;
	NOT;
	UW;
	-R;
	L 0;
	SV T 42;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	<>R;
	MOD;
	TAK;
	+R;
	XN FALSE;
	L 0;
	CLR;
	SPU AAYW;
AAYW:	NOP 0;
	LEAVE;
	<=D;
	>R;
	>=D;
	L 0;
	BTI;
	UN(;
	);
	COS;
	L 0;
	CLR;
	SPS AAYX;
AAYX:	NOP 0;
	L 0;
	CLR;
	SPZ AAYY;
AAYY:	NOP 0;
	T MD 0;
	L 0;
	CLR;
	SPBB AAYZ;
AAYZ:	NOP 0;
	ITB;
	<I;
	==D;
	INVI;
	U M 0.4;
	LC MW 0;
	ON M 0.4;
	TAR2;
	RLDA;
	RLDA;
	XOD;
	UN M 0.4;
	UC FC 44;
	RRD;
	RND+;
	NEGR;
	NOP 0;
	SLW;
	TAR1;
	EXP;
	LAR2;
	S M 0.4;
	SET;
	SET;
	UN M 0.4;
	FR Z 42;
	TAK;
	L 0;
	CLR;
	SPB AAZA;
AAZA:	NOP 0;
	POP;
	NEGI;
	U(;
	);
	L 0;
	BTD;
	>=D;
	O(;
	);
	*I;
	ON FALSE;
	O TRUE;
	L 0;
	CLR;
	SPMZ AAZB;
AAZB:	NOP 0;
	SET;
	U(;
	);
	==I;
	SIN;
	L 0;
	BTI;
	>R;
	L 0;
	CLR;
	SPBN AAZC;
AAZC:	NOP 0;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	DEC 0;
	ENT;
	L 0;
	BTI;
	TAR1;
	+AR2;
	+D;
	ON FALSE;
	L 0;
	CLR;
	SPBIN AAZD;
AAZD:	NOP 0;
	L 0;
	CLR;
	SPM AAZE;
AAZE:	NOP 0;
	*D;
	+R;
	XN(;
	);
	ASIN;
	TAK;
	X(;
	);
	L 0;
	CLR;
	SPBNB AAZF;
AAZF:	NOP 0;
	SSD;
	<>D;
	>=I;
	L 0;
	L 0;
	CLR;
	SPL AAZG;
AAZG:	NOP 0;
	L 0;
	CLR;
	SPMZ AAZH;
AAZH:	NOP 0;
	UW;
	LN;
	UW;
	NEGI;
	NEGI;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	O(;
	);
	==I;
	DEC 0;
	OW;
	SET;
	SLD;
	CC FC 43;
	L 0;
	CLR;
	SPBB AAZI;
AAZI:	NOP 0;
	ASIN;
	UC FC 44;
	L 0;
	CLR;
	SPP AAZJ;
AAZJ:	NOP 0;
	ZR Z 42;
	UW;
	+AR1;
	/I;
	==D;
	LEAVE;
	RLDA;
	L 0;
	SA T 42;
	RLDA;
	RRD;
	ITB;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	TRUNC;
	L 0;
	CLR;
	SPBNB AAZK;
AAZK:	NOP 0;
	DTB;
	U M 0.4;
	<I;
	U TRUE;
	<I;
	NEGI;
	SIN;
	LN;
	XN TRUE;
	*I;
	ENT;
	NEGD;
	O M 0.4;
	INVI;
	L 0;
	CLR;
	SPBN AAZL;
AAZL:	NOP 0;
	ZV Z 42;
	XN(;
	);
	L 0;
	CLR;
	SPS AAZM;
AAZM:	NOP 0;
	L 0;
	CLR;
	SPBIN AAZN;
AAZN:	NOP 0;
	L 0;
	SI T 42;
	TAK;
	L 0;
	CLR;
	SPM AAZO;
AAZO:	NOP 0;
	UN M 0.4;
	>I;
	L 0;
	CLR;
	SPU AAZP;
AAZP:	NOP 0;
	+I;
	ABS;
	INC 0;
	UN FALSE;
	DTB;
	L 0;
	CLR;
	SPMZ AAZQ;
AAZQ:	NOP 0;
	L 0;
	CLR;
	LOOP AAZR;
AAZR:	NOP 0;
	SRW;
	SLW;
	ON FALSE;
	SLD;
	==R;
	TAR2;
	UD;
	L 0;
	CLR;
	SPU AAZS;
AAZS:	NOP 0;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	LN;
	O(;
	);
	L 0;
	SA T 42;
	L 0;
	CLR;
	SPBIN AAZT;
AAZT:	NOP 0;
	LEAVE;
	L 0;
	CLR;
	SPN AAZU;
AAZU:	NOP 0;
	POP;
	UD;
	X M 0.4;
	NEGI;
	+AR1;
	L 0;
	CLR;
	SPMZ AAZV;
AAZV:	NOP 0;
	/I;
	X(;
	);
	<=D;
	L 0;
	CLR;
	SPB AAZW;
AAZW:	NOP 0;
	UN TRUE;
	MOD;
	XOW;
	<R;
	DEC 0;
	UC FC 44;
	*R;
	L 0;
	BTD;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	>I;
	L 0;
	CLR;
	SPS AAZX;
AAZX:	NOP 0;
	L 0;
	CLR;
	SPN AAZY;
AAZY:	NOP 0;
	O TRUE;
	LN;
	SET;
	RLDA;
	RND+;
	/D;
	TAR;
	L 0;
	CLR;
	SPO AAZZ;
AAZZ:	NOP 0;
	NEGR;
	UW;
	L 0;
	CLR;
	SPO ABAA;
ABAA:	NOP 0;
	<=R;
	<>I;
	/D;
	ON FALSE;
	CLR;
	LAR2;
	L 0;
	SI T 42;
	U TRUE;
	RRDA;
	==R;
	ITD;
	+I;
	SLD;
	UW;
	L 0;
	CLR;
	SPZ ABAB;
ABAB:	NOP 0;
	L 0;
	CLR;
	SPPZ ABAC;
ABAC:	NOP 0;
	<D;
	FN M 0.4;
	L 0;
	SS T 42;
	==D;
	INVD;
	ON TRUE;
	*R;
	L 0;
	SA T 42;
	>I;
	UN M 0.4;
	L 0;
	CLR;
	SPZ ABAD;
ABAD:	NOP 0;
	XN FALSE;
	L 0;
	CLR;
	SPU ABAE;
ABAE:	NOP 0;
	SSI;
	XN FALSE;
	L 0;
	SA T 42;
	L 0;
	CLR;
	SPZ ABAF;
ABAF:	NOP 0;
	XN M 0.4;
	+AR1;
	L 0;
	CLR;
	SPZ ABAG;
ABAG:	NOP 0;
	NEGI;
	L 0;
	CLR;
	SPM ABAH;
ABAH:	NOP 0;
	INVI;
	DTB;
	L 0;
	CLR;
	SPBB ABAI;
ABAI:	NOP 0;
	L 0;
	L 0;
	CLR;
	SPL ABAJ;
ABAJ:	NOP 0;
	XOW;
	L 0;
	CLR;
	SPP ABAK;
ABAK:	NOP 0;
	LAR1;
	<I;
	L 0;
	CLR;
	SPA ABAL;
ABAL:	NOP 0;
	<=D;
	<>R;
	L 0;
	L 0;
	CLR;
	SPL ABAM;
ABAM:	NOP 0;
	>I;
	ON M 0.4;
	ENT;
	L 0;
	SE T 42;
	FP M 0.4;
	INVD;
	OD;
	*I;
	TAK;
	L 0;
	CLR;
	SPP ABAN;
ABAN:	NOP 0;
	L 0;
	CLR;
	SPA ABAO;
ABAO:	NOP 0;
	<D;
	L 0;
	CLR;
	SPBN ABAP;
ABAP:	NOP 0;
	DEC 0;
	FR Z 42;
	>=R;
	= M 0.4;
	L 0;
	CLR;
	SPZ ABAQ;
ABAQ:	NOP 0;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	L 0;
	CLR;
	LOOP ABAR;
ABAR:	NOP 0;
	OD;
	LAR2;
	U(;
	);
	==D;
	UN TRUE;
	U(;
	);
	==I;
	-R;
	UN(;
	);
	SET;
	ASIN;
	/R;
	L 0;
	BTI;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	T MD 0;
	+ 0;
	L 0;
	CLR;
	SPZ ABAS;
ABAS:	NOP 0;
	L 0;
	CLR;
	SPU ABAT;
ABAT:	NOP 0;
	DTR;
	XOW;
	S M 0.4;
	SSI;
	INC 0;
	==D;
	CLR;
	SSI;
	SAVE;
	TAR1;
	L 0;
	CLR;
	SPZ ABAU;
ABAU:	NOP 0;
	SSI;
	SSD;
	TRUNC;
	TAD;
	<D;
	ZR Z 42;
	-D;
	/R;
	ITB;
	L 0;
	CLR;
	SPMZ ABAV;
ABAV:	NOP 0;
	L 0;
	CLR;
	SPPZ ABAW;
ABAW:	NOP 0;
	TAR1;
	SRD;
	UN FALSE;
	SLW;
	<>I;
	*I;
	SRW;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	>=R;
	L 0;
	CLR;
	SPBN ABAX;
ABAX:	NOP 0;
	*I;
	CC FC 43;
	+AR1;
	<=I;
	L 0;
	SV T 42;
	FP M 0.4;
	SQRT;
	==I;
	L 0;
	CLR;
	SPPZ ABAY;
ABAY:	NOP 0;
	POP;
	= M 0.4;
	L 0;
	CLR;
	SPO ABAZ;
ABAZ:	NOP 0;
	XOW;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	SQR;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	LN;
	RND-;
	FR Z 42;
	TAK;
	<>R;
	SLD;
	-R;
	X(;
	);
	+I;
	NEGI;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	ACOS;
	ATAN;
	INC 0;
	+I;
	XOD;
	RND+;
	<=R;
	R M 0.4;
	DEC 0;
	SRD;
	>I;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	L 0;
	CLR;
	SPPZ ABBA;
ABBA:	NOP 0;
	POP;
	SAVE;
	LAR2;
	L 0;
	BTI;
	L 0;
	CLR;
	SPS ABBB;
ABBB:	NOP 0;
	SQRT;
	XN(;
	);
	SET;
	==I;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	+R;
	L 0;
	CLR;
	SPPZ ABBC;
ABBC:	NOP 0;
	RRD;
	ON(;
	);
	CLR;
	NEGR;
	>D;
	+AR2;
	U M 0.4;
	>=D;
	<=D;
	TAR;
	XOW;
	L 0;
	CLR;
	SPBNB ABBD;
ABBD:	NOP 0;
	*R;
	+AR1;
	T MD 0;
	DTR;
	INVD;
	L 0;
	CLR;
	SPP ABBE;
ABBE:	NOP 0;
	L 0;
	CLR;
	SPBIN ABBF;
ABBF:	NOP 0;
	INC 0;
	L 0;
	CLR;
	SPO ABBG;
ABBG:	NOP 0;
	ATAN;
	-I;
	SET;
	BLD 0;
	O M 0.4;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	L 0;
	SV T 42;
	SQRT;
	<=I;
	L 0;
	CLR;
	SPBI ABBH;
ABBH:	NOP 0;
	ON(;
	);
	*D;
	TAK;
	UN(;
	);
	U M 0.4;
	ENT;
	+ 0;
	<>I;
	L 0;
	CLR;
	SPBN ABBI;
ABBI:	NOP 0;
	UN FALSE;
	ACOS;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	/R;
	L 0;
	CLR;
	SPP ABBJ;
ABBJ:	NOP 0;
	+R;
	SQRT;
	+R;
	ATAN;
	XOD;
	NEGD;
	<=R;
	SLW;
	>D;
	ITD;
	POP;
	-R;
	+D;
	SIN;
	==R;
	L 0;
	CLR;
	SPBB ABBK;
ABBK:	NOP 0;
	<=I;
	<>D;
	O M 0.4;
	= M 0.4;
	X M 0.4;
	<D;
	SRD;
	ATAN;
	<>D;
	NOT;
	>D;
	SIN;
	TAR1;
	CC FC 43;
	TAN;
	ITB;
	TAR1;
	L 0;
	SV T 42;
	TAN;
	PUSH;
	TAR;
	-R;
	/I;
	TAD;
	L 0;
	BTD;
	TAN;
	CC FC 43;
	UN M 0.4;
	+AR1;
	RLDA;
	RND+;
	RRDA;
	TDB;
	LN;
	XOD;
	+AR1;
	-D;
	O FALSE;
	INC 0;
	SLD;
	*D;
	<>I;
	+AR2;
	SLD;
	S M 0.4;
	<D;
	UW;
	L 0;
	CLR;
	SPB ABBL;
ABBL:	NOP 0;
	SSI;
	L 0;
	SS T 42;
	S M 0.4;
	L 0;
	SA T 42;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	SET;
	FR Z 42;
	SSD;
	R M 0.4;
	OD;
	+AR2;
	L 0;
	CLR;
	SPZ ABBM;
ABBM:	NOP 0;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	UN(;
	);
	+I;
	XOW;
	O M 0.4;
	SSD;
	TAR1;
	L 0;
	SE T 42;
	SSD;
	DEC 0;
	L 0;
	CLR;
	SPMZ ABBN;
ABBN:	NOP 0;
	COS;
	/I;
	L 0;
	CLR;
	SPBI ABBO;
ABBO:	NOP 0;
	L 0;
	CLR;
	SPBNB ABBP;
ABBP:	NOP 0;
	<R;
	ON TRUE;
	LEAVE;
	ZR Z 42;
	ON(;
	);
	SLW;
	+AR2;
	>=R;
	DEC 0;
	UN(;
	);
	L 0;
	CLR;
	SPBNB ABBQ;
ABBQ:	NOP 0;
	U TRUE;
	SRD;
	NOT;
	<=I;
	L 0;
	SI T 42;
	R M 0.4;
	L 0;
	CLR;
	SPB ABBR;
ABBR:	NOP 0;
	LC MW 0;
	==D;
	L 0;
	CLR;
	SPB ABBS;
ABBS:	NOP 0;
	L 0;
	L 0;
	CLR;
	SPL ABBT;
ABBT:	NOP 0;
	ZV Z 42;
	ON M 0.4;
	<>I;
	CC FC 43;
	<=R;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	<=D;
	T MD 0;
	*D;
	<=R;
	ZR Z 42;
	RND+;
	SRD;
	ITB;
	OW;
	O TRUE;
	NOT;
	>=D;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	==R;
	RRD;
	LN;
	-R;
	RND+;
	LAR1;
	<R;
	NEGI;
	+AR1;
	-I;
	UN(;
	);
	AUF DB 42;
	>I;
	UN(;
	);
	<R;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	SQR;
	SLW;
	L 0;
	CLR;
	SPO ABBU;
ABBU:	NOP 0;
	SLW;
	XOW;
	TRUNC;
	+R;
	*R;
	SLW;
	AUF DB 42;
	>=D;
	OW;
	ATAN;
	ON M 0.4;
	L 0;
	CLR;
	SPBB ABBV;
ABBV:	NOP 0;
	T MD 0;
	+R;
	L 0;
	CLR;
	SPN ABBW;
ABBW:	NOP 0;
	OW;
	X FALSE;
	XOW;
	/I;
	ACOS;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	L 0;
	CLR;
	SPA ABBX;
ABBX:	NOP 0;
	L 0;
	CLR;
	SPU ABBY;
ABBY:	NOP 0;
	L 0;
	CLR;
	SPA ABBZ;
ABBZ:	NOP 0;
	TDB;
	FN M 0.4;
	ZV Z 42;
	BLD 0;
	/R;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	RND-;
	NOP 0;
	DTB;
	L 0;
	SA T 42;
	L 0;
	CLR;
	LOOP ABCA;
ABCA:	NOP 0;
	ITB;
	L 0;
	CLR;
	SPN ABCB;
ABCB:	NOP 0;
	TAK;
	O M 0.4;
	O M 0.4;
	XN(;
	);
	ON M 0.4;
	LN;
	FN M 0.4;
	UW;
	FP M 0.4;
	T MD 0;
	*I;
	TAW;
	L 0;
	CLR;
	SPBN ABCC;
ABCC:	NOP 0;
	LC MW 0;
	DTB;
	O FALSE;
	CLR;
	O(;
	);
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	NEGR;
	SET;
	>=I;
	<I;
	SET;
	CC FC 43;
	==D;
	MOD;
	LEAVE;
	L 0;
	BTD;
	<>I;
	L 0;
	BTD;
	LC MW 0;
	L 0;
	CLR;
	SPBI ABCD;
ABCD:	NOP 0;
	SSI;
	R M 0.4;
	TAR1;
	L 0;
	L 0;
	CLR;
	SPL ABCE;
ABCE:	NOP 0;
	ASIN;
	L 0;
	CLR;
	SPM ABCF;
ABCF:	NOP 0;
	ZV Z 42;
	>R;
	= M 0.4;
	L 0;
	L 0;
	CLR;
	SPL ABCG;
ABCG:	NOP 0;
	ON(;
	);
	+R;
	*R;
	L 0;
	CLR;
	SPU ABCH;
ABCH:	NOP 0;
	ON(;
	);
	ZR Z 42;
	AUF DB 42;
	L 0;
	BTI;
	LAR1;
	XN(;
	);
	RLD;
	INVI;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	/R;
	L 0;
	BTI;
	RLD;
	==I;
	<D;
	OD;
	ACOS;
	NEGR;
	==I;
	LAR2;
	ZR Z 42;
	FP M 0.4;
	O FALSE;
	= M 0.4;
	DEC 0;
	LC MW 0;
	T MD 0;
	X M 0.4;
	RLDA;
	<=D;
	U M 0.4;
	ON TRUE;
	TDB;
	<=D;
	L 0;
	CLR;
	SPMZ ABCI;
ABCI:	NOP 0;
	/R;
	+AR1;
	U M 0.4;
	L 0;
	SE T 42;
	RLD;
	SRW;
	ATAN;
	SQRT;
	XN(;
	);
	OD;
	TAD;
	U M 0.4;
	-R;
	SLD;
	>=I;
	INC 0;
	UD;
	+ 0;
	L 0;
	CLR;
	SPU ABCJ;
ABCJ:	NOP 0;
	L 0;
	CLR;
	SPO ABCK;
ABCK:	NOP 0;
	SQR;
	O(;
	);
	CLR;
	-D;
	XOW;
	+I;
	S M 0.4;
	TAR2;
	L 0;
	CLR;
	SPBNB ABCL;
ABCL:	NOP 0;
	INVI;
	L 0;
	BTI;
	PUSH;
	X TRUE;
	ITD;
	L 0;
	CLR;
	SPBIN ABCM;
ABCM:	NOP 0;
	*R;
	==I;
	+ 0;
	SRD;
	NOT;
	LAR1;
	ITD;
	>D;
	ON FALSE;
	U FALSE;
	RLD;
	*R;
	X(;
	);
	OD;
	L 0;
	CLR;
	SPS ABCN;
ABCN:	NOP 0;
	RLDA;
	XOW;
	TAR;
	X M 0.4;
	ON TRUE;
	O(;
	);
	L 0;
	CLR;
	LOOP ABCO;
ABCO:	NOP 0;
	X TRUE;
	<I;
	NEGD;
	L 0;
	SA T 42;
	TAR2;
	UD;
	<=D;
	+AR2;
	TRUNC;
	= M 0.4;
	ON FALSE;
	RLD;
	X M 0.4;
	SSD;
	XN FALSE;
	==D;
	ON M 0.4;
	<=R;
	U(;
	);
	L 0;
	CLR;
	SPS ABCP;
ABCP:	NOP 0;
	SAVE;
	TAR1;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	>=R;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	X(;
	);
	==I;
	>I;
	RLDA;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	TAW;
	X(;
	);
	INVI;
	ASIN;
	L 0;
	CLR;
	LOOP ABCQ;
ABCQ:	NOP 0;
	SQR;
	L 0;
	CLR;
	SPPZ ABCR;
ABCR:	NOP 0;
	<I;
	+AR1;
	XOD;
	>D;
	L 0;
	CLR;
	SPM ABCS;
ABCS:	NOP 0;
	NEGD;
	XN FALSE;
	L 0;
	CLR;
	SPU ABCT;
ABCT:	NOP 0;
	X(;
	);
	<I;
	L 0;
	L 0;
	CLR;
	SPL ABCU;
ABCU:	NOP 0;
	<D;
	SIN;
	>=R;
	*D;
	PUSH;
	<R;
	LAR1;
	FR Z 42;
	+AR2;
	X FALSE;
	FN M 0.4;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	MOD;
	<>R;
	X M 0.4;
	SRD;
	S M 0.4;
	UN M 0.4;
	UN M 0.4;
	L 0;
	BTI;
	SET;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	L 0;
	CLR;
	SPBN ABCV;
ABCV:	NOP 0;
	SIN;
	SLW;
	<=I;
	INVD;
	<D;
	L 0;
	CLR;
	SPA ABCW;
ABCW:	NOP 0;
	L 0;
	SA T 42;
	TAR;
	LN;
	RND-;
	<=R;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	ON FALSE;
	RLDA;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	SET;
	L 0;
	CLR;
	SPO ABCX;
ABCX:	NOP 0;
	*I;
	COS;
	UN M 0.4;
	POP;
	RND+;
	DTB;
	<I;
	OW;
	SAVE;
	+D;
	OD;
	L 0;
	SI T 42;
	TAW;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	NEGI;
	L 0;
	L 0;
	CLR;
	SPL ABCY;
ABCY:	NOP 0;
	UN(;
	);
	DTB;
	<>I;
	<=D;
	SLW;
	RLDA;
	L 0;
	BTI;
	<>R;
	XN FALSE;
	-D;
	L 0;
	CLR;
	SPBN ABCZ;
ABCZ:	NOP 0;
	NEGI;
	ATAN;
	LC MW 0;
	L 0;
	CLR;
	SPU ABDA;
ABDA:	NOP 0;
	TAR1;
	XN FALSE;
	UN(;
	);
	UD;
	L 0;
	BTI;
	<>R;
	UN TRUE;
	L 0;
	SE T 42;
	>I;
	= M 0.4;
	RND+;
	LAR2;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	+AR2;
	L 0;
	CLR;
	SPPZ ABDB;
ABDB:	NOP 0;
	COS;
	DTR;
	L 0;
	CLR;
	SPPZ ABDC;
ABDC:	NOP 0;
	RND;
	<>I;
	L 0;
	CLR;
	SPPZ ABDD;
ABDD:	NOP 0;
	RND;
	FN M 0.4;
	RND+;
	LN;
	INVI;
	MOD;
	TAW;
	= M 0.4;
	SSD;
	BLD 0;
	SRD;
	UN(;
	);
	ATAN;
	>=D;
	NEGR;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	TAR1;
	L 0;
	BTI;
	*R;
	/D;
	<>D;
	TAR2;
	DTB;
	+ 0;
	L 0;
	CLR;
	SPA ABDE;
ABDE:	NOP 0;
	INVI;
	L 0;
	CLR;
	SPU ABDF;
ABDF:	NOP 0;
	<=I;
	O FALSE;
	L 0;
	CLR;
	SPB ABDG;
ABDG:	NOP 0;
	<>D;
	<>I;
	SSI;
	TAR2;
	COS;
	>=R;
	+I;
	TAW;
	L 0;
	CLR;
	SPBI ABDH;
ABDH:	NOP 0;
	CC FC 43;
	<>R;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	>=R;
	+AR1;
	PUSH;
	RND;
	SET;
	LN;
	L 0;
	SA T 42;
	RLD;
	NEGR;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	SLW;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	L 0;
	CLR;
	SPB ABDI;
ABDI:	NOP 0;
	ON M 0.4;
	ASIN;
	L DW#16#3F71E1AE;
	ATAN;
	+AR2;
	TAW;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	<=D;
	DEC 0;
	UN M 0.4;
	SIN;
	XN FALSE;
	SSD;
	L 0;
	SI T 42;
	O TRUE;
	OW;
	/R;
	SRW;
	FN M 0.4;
	TAR;
	RRD;
	RND-;
	NOT;
	POP;
	ON M 0.4;
	EXP;
	NEGR;
	==D;
	+ 0;
	L 0;
	CLR;
	SPBI ABDJ;
ABDJ:	NOP 0;
	RND-;
	CLR;
	X M 0.4;
	SRW;
	L 0;
	CLR;
	SPS ABDK;
ABDK:	NOP 0;
	>R;
	TAR2;
	DEC 0;
	BLD 0;
	U TRUE;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	>D;
	SQRT;
	L 0;
	BTD;
	*D;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	U M 0.4;
	= M 0.4;
	-R;
	L 0;
	CLR;
	SPU ABDL;
ABDL:	NOP 0;
	OW;
	O TRUE;
	ASIN;
	L 0;
	CLR;
	SPA ABDM;
ABDM:	NOP 0;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	OD;
	+AR1;
	NEGI;
	S M 0.4;
	L 0;
	CLR;
	SPU ABDN;
ABDN:	NOP 0;
	O(;
	);
	L 0;
	SE T 42;
	-D;
	UN(;
	);
	<>I;
	-R;
	-D;
	SSI;
	X TRUE;
	-D;
	<=R;
	ENT;
	XN(;
	);
	ENT;
	INVD;
	>D;
	L 0;
	CLR;
	SPU ABDO;
ABDO:	NOP 0;
	RND-;
	OD;
	>I;
	SRW;
	+AR2;
	NEGI;
	TAD;
	L 0;
	CLR;
	SPM ABDP;
ABDP:	NOP 0;
	/I;
	TDB;
	RRDA;
	TAN;
	L 0;
	L 0;
	CLR;
	SPL ABDQ;
ABDQ:	NOP 0;
	UN(;
	);
	X(;
	);
	/D;
	-I;
	TAR;
	SRD;
	RRDA;
	UW;
	>=I;
	SSD;
	XOW;
	XOW;
	L 0;
	CLR;
	SPBNB ABDR;
ABDR:	NOP 0;
	TAR;
	*D;
	X(;
	);
	ITD;
	TAR2;
	SET;
	S M 0.4;
	/R;
	L 0;
	BTI;
	L 0;
	CLR;
	SPBB ABDS;
ABDS:	NOP 0;
	R M 0.4;
	==I;
	<R;
	L 0;
	L 0;
	CLR;
	SPL ABDT;
ABDT:	NOP 0;
	<>I;
	>=D;
	RLDA;
	<=D;
	INVD;
	L 0;
	SA T 42;
	XN M 0.4;
	L 0;
	CLR;
	SPBI ABDU;
ABDU:	NOP 0;
	SIN;
	OD;
	==D;
	SLW;
	-I;
	COS;
	LAR2;
	XN M 0.4;
	L 0;
	CLR;
	SPBNB ABDV;
ABDV:	NOP 0;
	ITD;
	X(;
	);
	XN M 0.4;
	TRUNC;
	L 0;
	SA T 42;
	L 0;
	CLR;
	SPU ABDW;
ABDW:	NOP 0;
	LN;
	+AR2;
	+I;
	L 0;
	CLR;
	SPPZ ABDX;
ABDX:	NOP 0;
	SRD;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	OW;
	TAK;
	LAR2;
	TAR2;
	L 0;
	CLR;
	SPO ABDY;
ABDY:	NOP 0;
	INC 0;
	==D;
	L 0;
	CLR;
	SPS ABDZ;
ABDZ:	NOP 0;
	>=R;
	ZR Z 42;
	RND;
	SLD;
	/D;
	L 0;
	CLR;
	SPBB ABEA;
ABEA:	NOP 0;
	U(;
	);
	>=D;
	/I;
	L 0;
	CLR;
	SPBN ABEB;
ABEB:	NOP 0;
	TAR1;
	<R;
	>R;
	UD;
	L 0;
	CLR;
	SPBB ABEC;
ABEC:	NOP 0;
	ITB;
	<=R;
	==R;
	>R;
	RND+;
	>I;
	X TRUE;
	+AR1;
	<=I;
	LAR1;
	ZR Z 42;
	*D;
	L 0;
	BTD;
	INVD;
	ENT;
	O TRUE;
	-I;
	>=D;
	/D;
	T MD 0;
	OD;
	>R;
	XOW;
	L 0;
	CLR;
	SPO ABED;
ABED:	NOP 0;
	>=I;
	U TRUE;
	RLDA;
	>=D;
	TAR2;
	L 0;
	CLR;
	SPP ABEE;
ABEE:	NOP 0;
	==R;
	UN M 0.4;
	XOD;
	L 0;
	SI T 42;
	L 0;
	CLR;
	SPMZ ABEF;
ABEF:	NOP 0;
	L 0;
	CLR;
	SPBI ABEG;
ABEG:	NOP 0;
	SLW;
	L 0;
	CLR;
	SPBNB ABEH;
ABEH:	NOP 0;
	DEC 0;
	>=D;
	LEAVE;
	LAR2;
	L 0;
	CLR;
	LOOP ABEI;
ABEI:	NOP 0;
	<>I;
	SRW;
	X FALSE;
	PUSH;
	>I;
	L 0;
	CLR;
	SPS ABEJ;
ABEJ:	NOP 0;
	U TRUE;
	TAW;
	T MD 0;
	+ 0;
	CLR;
	L 0;
	CLR;
	SPPZ ABEK;
ABEK:	NOP 0;
	O(;
	);
	UC FC 44;
	DTB;
	BLD 0;
	UW;
	TAW;
	L 0;
	CLR;
	SPB ABEL;
ABEL:	NOP 0;
	DTR;
	XN M 0.4;
	NOT;
	UD;
	T MD 0;
	SET;
	L 0;
	SE T 42;
	/R;
	DTB;
	RLD;
	L 0;
	CLR;
	SPP ABEM;
ABEM:	NOP 0;
	CC FC 43;
	CC FC 43;
	L 0;
	SV T 42;
	O(;
	);
	+D;
	ABS;
	>=D;
	ASIN;
	*D;
	-R;
	/D;
	ON M 0.4;
	L 0;
	CLR;
	SPBN ABEN;
ABEN:	NOP 0;
	-I;
	*I;
	L 0;
	CLR;
	SPS ABEO;
ABEO:	NOP 0;
	T MD 0;
	ENT;
	SET;
	NEGR;
	LAR2;
	SIN;
	LAR2;
	L 0;
	CLR;
	SPBB ABEP;
ABEP:	NOP 0;
	>R;
	TAN;
	SIN;
	>D;
	NOP 0;
	SET;
	SET;
	<D;
	NEGI;
	L 0;
	CLR;
	SPO ABEQ;
ABEQ:	NOP 0;
	SLW;
	UW;
	L 0;
	CLR;
	SPU ABER;
ABER:	NOP 0;
	X(;
	);
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	MOD;
	SET;
	UN M 0.4;
	EXP;
	L 0;
	CLR;
	SPA ABES;
ABES:	NOP 0;
	SIN;
	<=R;
	POP;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	INC 0;
	>D;
	INVI;
	L 0;
	BTD;
	+R;
	L 0;
	CLR;
	SPBNB ABET;
ABET:	NOP 0;
	PUSH;
	RLD;
	X TRUE;
	BLD 0;
	L 0;
	CLR;
	SPO ABEU;
ABEU:	NOP 0;
	RRD;
	ENT;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	TAD;
	U FALSE;
	==R;
	AUF DB 42;
	L 0;
	CLR;
	SPBIN ABEV;
ABEV:	NOP 0;
	SSD;
	>=I;
	L 0;
	CLR;
	SPBB ABEW;
ABEW:	NOP 0;
	SIN;
	L 0;
	BTI;
	RLD;
	FR Z 42;
	UN FALSE;
	L 0;
	L 0;
	CLR;
	SPL ABEX;
ABEX:	NOP 0;
	RRD;
	XN(;
	);
	SET;
	+D;
	+AR2;
	SLD;
	LEAVE;
	ATAN;
	ZR Z 42;
	SLW;
	<I;
	/D;
	L 0;
	SE T 42;
	+AR1;
	X M 0.4;
	ZR Z 42;
	>R;
	+AR2;
	O(;
	);
	>=D;
	L 0;
	CLR;
	SPP ABEY;
ABEY:	NOP 0;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	<>D;
	+ 0;
	>R;
	UN(;
	);
	L 0;
	CLR;
	SPA ABEZ;
ABEZ:	NOP 0;
	+D;
	COS;
	+ 0;
	U(;
	);
	L 0;
	CLR;
	SPBNB ABFA;
ABFA:	NOP 0;
	L 0;
	CLR;
	SPBNB ABFB;
ABFB:	NOP 0;
	OW;
	R M 0.4;
	L 0;
	SE T 42;
	DTB;
	ITB;
	SAVE;
	SET;
	<R;
	XOD;
	L 0;
	CLR;
	SPM ABFC;
ABFC:	NOP 0;
	L 0;
	CLR;
	SPN ABFD;
ABFD:	NOP 0;
	L 0;
	CLR;
	SPO ABFE;
ABFE:	NOP 0;
	L 0;
	CLR;
	SPA ABFF;
ABFF:	NOP 0;
	+D;
	SAVE;
	XOW;
	+AR2;
	/I;
	<D;
	ON M 0.4;
	>D;
	L 0;
	SS T 42;
	L 0;
	CLR;
	SPBN ABFG;
ABFG:	NOP 0;
	/D;
	SRD;
	LN;
	+I;
	>R;
	FP M 0.4;
	NEGR;
	==R;
	RRDA;
	TAW;
	ITD;
	ENT;
	UW;
	XOW;
	PUSH;
	>I;
	SIN;
	TAR2;
	R M 0.4;
	>I;
	==D;
	X M 0.4;
	SRW;
	*I;
	L 0;
	CLR;
	SPZ ABFH;
ABFH:	NOP 0;
	+D;
	>D;
	LAR2;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	L 0;
	SA T 42;
	+I;
	<=R;
	L 0;
	CLR;
	SPO ABFI;
ABFI:	NOP 0;
	UN FALSE;
	TAW;
	<=I;
	<D;
	RND;
	L 0;
	CLR;
	SPS ABFJ;
ABFJ:	NOP 0;
	<=I;
	NEGI;
	==D;
	S M 0.4;
	TAN;
	<>I;
	R M 0.4;
	X M 0.4;
	SLD;
	ACOS;
	X FALSE;
	==I;
	O FALSE;
	SSD;
	<I;
	LC MW 0;
	XN FALSE;
	L 0;
	CLR;
	SPO ABFK;
ABFK:	NOP 0;
	O M 0.4;
	SAVE;
	>=I;
	CC FC 43;
	INVD;
	NOP 0;
	INVI;
	L 0;
	BTD;
	*I;
	UN FALSE;
	>=D;
	L 0;
	CLR;
	SPB ABFL;
ABFL:	NOP 0;
	+AR2;
	*I;
	/I;
	>R;
	RRDA;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	RND-;
	L 0;
	SI T 42;
	INC 0;
	XN(;
	);
	FN M 0.4;
	+AR2;
	ON M 0.4;
	OW;
	NEGR;
	DTB;
	L 0;
	CLR;
	SPBN ABFM;
ABFM:	NOP 0;
	>=R;
	UD;
	UN M 0.4;
	FN M 0.4;
	NEGD;
	L 0;
	SI T 42;
	SLW;
	-D;
	NOP 0;
	L 0;
	BTD;
	LAR1;
	==I;
	ITB;
	/I;
	+R;
	TAN;
	NEGD;
	L 0;
	SE T 42;
	RND;
	EXP;
	<>I;
	L 0;
	CLR;
	SPN ABFN;
ABFN:	NOP 0;
	>=I;
	SSI;
	<>I;
	L 0;
	SA T 42;
	<>D;
	RRD;
	+D;
	L 0;
	CLR;
	SPBB ABFO;
ABFO:	NOP 0;
	POP;
	X FALSE;
	L 0;
	CLR;
	SPPZ ABFP;
ABFP:	NOP 0;
	RRD;
	>I;
	-R;
	L 0;
	CLR;
	SPBN ABFQ;
ABFQ:	NOP 0;
	TAR1;
	SET;
	L 0;
	CLR;
	SPZ ABFR;
ABFR:	NOP 0;
	LAR2;
	TAD;
	PUSH;
	EXP;
	L 0;
	CLR;
	SPBNB ABFS;
ABFS:	NOP 0;
	ASIN;
	ITD;
	XN(;
	);
	SLW;
	*D;
	L 0;
	BTI;
	ON M 0.4;
	RLD;
	FP M 0.4;
	ABS;
	LAR1;
	L 0;
	SA T 42;
	NOT;
	<I;
	<D;
	ABS;
	SQR;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	FP M 0.4;
	>=R;
	X(;
	);
	-D;
	DTR;
	L 0;
	CLR;
	LOOP ABFT;
ABFT:	NOP 0;
	INVI;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	SQRT;
	>=I;
	TRUNC;
	TAN;
	RLDA;
	L 0;
	CLR;
	SPB ABFU;
ABFU:	NOP 0;
	+AR2;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	L 0;
	CLR;
	SPA ABFV;
ABFV:	NOP 0;
	SQR;
	+ 0;
	SLW;
	CC FC 43;
	SQRT;
	SRD;
	L 0;
	SV T 42;
	L 0;
	CLR;
	SPB ABFW;
ABFW:	NOP 0;
	>=D;
	TAR1;
	==I;
	>=I;
	LC MW 0;
	RLD;
	RLDA;
	TRUNC;
	<>D;
	UN FALSE;
	UN(;
	);
	XN(;
	);
	RLDA;
	U FALSE;
	+R;
	CC FC 43;
	L 0;
	CLR;
	SPPZ ABFX;
ABFX:	NOP 0;
	==R;
	L 0;
	CLR;
	SPO ABFY;
ABFY:	NOP 0;
	SAVE;
	R M 0.4;
	L 0;
	SA T 42;
	RRD;
	SSI;
	INVI;
	L 0;
	CLR;
	SPBI ABFZ;
ABFZ:	NOP 0;
	RLDA;
	RLD;
	L 0;
	SI T 42;
	ZR Z 42;
	OD;
	+I;
	OD;
	XOD;
	X M 0.4;
	O TRUE;
	<I;
	-R;
	TAR;
	L 0;
	CLR;
	SPN ABGA;
ABGA:	NOP 0;
	MOD;
	LAR2;
	TAR2;
	ON FALSE;
	L 0;
	BTI;
	POP;
	L 0;
	CLR;
	SPO ABGB;
ABGB:	NOP 0;
	<R;
	RLD;
	ACOS;
	<>D;
	L 0;
	CLR;
	SPZ ABGC;
ABGC:	NOP 0;
	*R;
	SRD;
	<>I;
	INC 0;
	RLD;
	PUSH;
	OD;
	DEC 0;
	SSD;
	SLW;
	ENT;
	<>R;
	L 0;
	SI T 42;
	O(;
	);
	/R;
	AUF DB 42;
	RRD;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	MOD;
	/I;
	L 0;
	CLR;
	SPBN ABGD;
ABGD:	NOP 0;
	L 0;
	CLR;
	SPM ABGE;
ABGE:	NOP 0;
	ON(;
	);
	UN FALSE;
	<=I;
	-D;
	*I;
	BLD 0;
	U TRUE;
	+R;
	SAVE;
	ASIN;
	-I;
	+ 0;
	LN;
	*I;
	O(;
	);
	FR Z 42;
	L DW#16#B020321B;
	L 0;
	CLR;
	SPS ABGF;
ABGF:	NOP 0;
	>I;
	L 0;
	CLR;
	LOOP ABGG;
ABGG:	NOP 0;
	>=R;
	XN M 0.4;
	UD;
	L 0;
	CLR;
	SPPZ ABGH;
ABGH:	NOP 0;
	ON TRUE;
	TAN;
	INC 0;
	L 0;
	SE T 42;
	COS;
	TDB;
	XN M 0.4;
	SSD;
	NOP 0;
	XN M 0.4;
	L 0;
	CLR;
	SPP ABGI;
ABGI:	NOP 0;
	MOD;
	DEC 0;
	*R;
	L 0;
	CLR;
	SPM ABGJ;
ABGJ:	NOP 0;
	DEC 0;
	FN M 0.4;
	RLD;
	FN M 0.4;
	INVD;
	L 0;
	CLR;
	LOOP ABGK;
ABGK:	NOP 0;
	RLDA;
	RRDA;
	L 0;
	CLR;
	LOOP ABGL;
ABGL:	NOP 0;
	<R;
	L 0;
	CLR;
	SPBIN ABGM;
ABGM:	NOP 0;
	-D;
	ATAN;
	INVI;
	RLDA;
	R M 0.4;
	UD;
	NEGD;
	L 0;
	CLR;
	SPBB ABGN;
ABGN:	NOP 0;
	AUF DB 42;
	U(;
	);
	L 0;
	CLR;
	SPBIN ABGO;
ABGO:	NOP 0;
	DEC 0;
	SQR;
	TAD;
	CLR;
	+AR2;
	SAVE;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	L 0;
	CLR;
	LOOP ABGP;
ABGP:	NOP 0;
	L 0;
	CLR;
	SPA ABGQ;
ABGQ:	NOP 0;
	XN(;
	);
	INC 0;
	OW;
	SLW;
	ASIN;
	NEGI;
	-I;
	R M 0.4;
	L 0;
	CLR;
	SPO ABGR;
ABGR:	NOP 0;
	L 0;
	SI T 42;
	L 0;
	CLR;
	SPBIN ABGS;
ABGS:	NOP 0;
	ACOS;
	OD;
	L 0;
	CLR;
	SPN ABGT;
ABGT:	NOP 0;
	INVI;
	SIN;
	SQR;
	LC MW 0;
	L 0;
	SE T 42;
	TAR1;
	TAK;
	ITB;
	X M 0.4;
	L 0;
	SS T 42;
	L 0;
	BTD;
	+AR1;
	RLDA;
	NEGD;
	SSI;
	TDB;
	XOW;
	ATAN;
	LEAVE;
	ON(;
	);
	L 0;
	SA T 42;
	INVI;
	-D;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	>=D;
	RND-;
	<=D;
	L 0;
	CLR;
	SPBIN ABGU;
ABGU:	NOP 0;
	ATAN;
	LN;
	L 0;
	CLR;
	SPP ABGV;
ABGV:	NOP 0;
	X(;
	);
	INVD;
	LN;
	TDB;
	L 0;
	CLR;
	SPBB ABGW;
ABGW:	NOP 0;
	>R;
	ZV Z 42;
	SET;
	RND+;
	SQRT;
	RND-;
	>I;
	<=D;
	DTB;
	UN FALSE;
	L 0;
	CLR;
	SPZ ABGX;
ABGX:	NOP 0;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	SRD;
	ENT;
	ATAN;
	TAN;
	ON FALSE;
	<>R;
	L 0;
	CLR;
	SPA ABGY;
ABGY:	NOP 0;
	<>D;
	UN TRUE;
	L 0;
	CLR;
	SPB ABGZ;
ABGZ:	NOP 0;
	TAK;
	L 0;
	BTI;
	X TRUE;
	XN M 0.4;
	O(;
	);
	NOT;
	L 0;
	CLR;
	SPN ABHA;
ABHA:	NOP 0;
	CC FC 43;
	L 0;
	CLR;
	SPBIN ABHB;
ABHB:	NOP 0;
	X(;
	);
	EXP;
	-D;
	CLR;
	ABS;
	>D;
	RND+;
	<>I;
	DEC 0;
	RRDA;
	<I;
	L 0;
	SA T 42;
	+AR2;
	UW;
	LC MW 0;
	RLDA;
	CLR;
	RND+;
	SET;
	>=I;
	L 0;
	CLR;
	SPN ABHC;
ABHC:	NOP 0;
	L 0;
	CLR;
	SPMZ ABHD;
ABHD:	NOP 0;
	BLD 0;
	*R;
	RND+;
	TAN;
	NEGR;
	<D;
	==I;
	<=R;
	NEGD;
	L 0;
	L 0;
	CLR;
	SPL ABHE;
ABHE:	NOP 0;
	LAR1;
	EXP;
	ZV Z 42;
	NOP 0;
	O(;
	);
	RLD;
	XOW;
	/D;
	<>I;
	L 0;
	CLR;
	SPP ABHF;
ABHF:	NOP 0;
	XOD;
	TAN;
	SLW;
	L DW#16#F69BD596;
	>=D;
	+D;
	SLW;
	*D;
	L 0;
	CLR;
	SPS ABHG;
ABHG:	NOP 0;
	XN M 0.4;
	UC FC 44;
	O FALSE;
	RND-;
	LC MW 0;
	PUSH;
	-R;
	L 0;
	CLR;
	SPZ ABHH;
ABHH:	NOP 0;
	+D;
	>=I;
	XOW;
	RND+;
	LAR2;
	*R;
	O M 0.4;
	/R;
	ZV Z 42;
	L 0;
	CLR;
	SPO ABHI;
ABHI:	NOP 0;
	CLR;
	RND+;
	L 0;
	CLR;
	SPBIN ABHJ;
ABHJ:	NOP 0;
	NEGI;
	>R;
	LAR1;
	L 0;
	CLR;
	SPP ABHK;
ABHK:	NOP 0;
	EXP;
	O TRUE;
	S M 0.4;
	RLD;
	SSD;
	LN;
	L 0;
	CLR;
	SPU ABHL;
ABHL:	NOP 0;
	TAN;
	FN M 0.4;
	>R;
	ZR Z 42;
	L 0;
	SI T 42;
	X(;
	);
	/I;
	COS;
	CC FC 43;
	TAK;
	L 0;
	CLR;
	SPPZ ABHM;
ABHM:	NOP 0;
	TAR1;
	UN FALSE;
	L 0;
	BTD;
	LAR2;
	<>D;
	U M 0.4;
	SQR;
	INVI;
	L 0;
	CLR;
	SPS ABHN;
ABHN:	NOP 0;
	L 0;
	CLR;
	SPN ABHO;
ABHO:	NOP 0;
	+AR1;
	NOT;
	<>I;
	<>R;
	L DW#16#C35EA18A;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	LN;
	L 0;
	CLR;
	SPP ABHP;
ABHP:	NOP 0;
	TAR;
	SRW;
	<>D;
	ZR Z 42;
	<=R;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	L 0;
	CLR;
	SPPZ ABHQ;
ABHQ:	NOP 0;
	L 0;
	CLR;
	SPBN ABHR;
ABHR:	NOP 0;
	DTR;
	NOT;
	SIN;
	*D;
	ITB;
	/R;
	MOD;
	DEC 0;
	TAD;
	XN M 0.4;
	XN M 0.4;
	POP;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	RND;
	SET;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	DTR;
	AUF DB 42;
	>=R;
	U(;
	);
	SQR;
	ASIN;
	SET;
	ZR Z 42;
	<=D;
	SET;
	*D;
	>=R;
	INC 0;
	<I;
	ON M 0.4;
	UW;
	ATAN;
	TAR1;
	RRD;
	<I;
	TAD;
	INVD;
	ITD;
	TDB;
	L 0;
	CLR;
	SPBB ABHS;
ABHS:	NOP 0;
	RRD;
	+R;
	==D;
	ACOS;
	INVD;
	SET;
	NEGR;
	L 0;
	CLR;
	SPBN ABHT;
ABHT:	NOP 0;
	ITD;
	COS;
	ITB;
	EXP;
	>=D;
	UN TRUE;
	AUF DB 42;
	RND+;
	TAR;
	L DW#16#754A3E48;
	O M 0.4;
	SSD;
	<>D;
	L 0;
	CLR;
	SPM ABHU;
ABHU:	NOP 0;
	ABS;
	NEGD;
	-R;
	TAN;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	ZV Z 42;
	= M 0.4;
	SAVE;
	POP;
	ON(;
	);
	UN(;
	);
	L 0;
	CLR;
	SPU ABHV;
ABHV:	NOP 0;
	RND+;
	SSD;
	/I;
	UC FC 44;
	SET;
	XN FALSE;
	LC MW 0;
	L 0;
	SI T 42;
	+R;
	L 0;
	CLR;
	SPO ABHW;
ABHW:	NOP 0;
	ABS;
	*D;
	==D;
	ENT;
	X FALSE;
	ZR Z 42;
	>=R;
	RRDA;
	RRD;
	L 0;
	CLR;
	LOOP ABHX;
ABHX:	NOP 0;
	SSI;
	==D;
	SET;
	L 0;
	CLR;
	SPP ABHY;
ABHY:	NOP 0;
	OW;
	ACOS;
	<D;
	ZR Z 42;
	>I;
	L 0;
	CLR;
	SPN ABHZ;
ABHZ:	NOP 0;
	XN FALSE;
	RLDA;
	L 0;
	CLR;
	SPB ABIA;
ABIA:	NOP 0;
	+D;
	ACOS;
	L 0;
	CLR;
	SPBN ABIB;
ABIB:	NOP 0;
	AUF DB 42;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	AUF DB 42;
	L 0;
	SS T 42;
	L 0;
	CLR;
	SPN ABIC;
ABIC:	NOP 0;
	ATAN;
	<R;
	L 0;
	CLR;
	SPN ABID;
ABID:	NOP 0;
	RLD;
	<=D;
	POP;
	LAR1;
	UN(;
	);
	ITD;
	<=D;
	UN(;
	);
	RND;
	ITB;
	ON TRUE;
	ZR Z 42;
	>R;
	SSI;
	ATAN;
	>I;
	RRD;
	X TRUE;
	+ 0;
	ENT;
	SRD;
	TAR2;
	RRD;
	<>I;
	>=D;
	>=I;
	*I;
	CLR;
	INVD;
	L 0;
	CLR;
	SPBN ABIE;
ABIE:	NOP 0;
	ITB;
	>=R;
	L 0;
	SV T 42;
	L 0;
	CLR;
	SPA ABIF;
ABIF:	NOP 0;
	LEAVE;
	BLD 0;
	NEGD;
	BLD 0;
	UN M 0.4;
	UW;
	DEC 0;
	ITB;
	SIN;
	R M 0.4;
	L DW#16#C4AC41B5;
	SAVE;
	L 0;
	CLR;
	SPMZ ABIG;
ABIG:	NOP 0;
	U TRUE;
	>=I;
	/R;
	/D;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	==I;
	L 0;
	CLR;
	SPM ABIH;
ABIH:	NOP 0;
	==R;
	UN FALSE;
	TAR2;
	SRW;
	TAR1;
	TDB;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	UN M 0.4;
	L 0;
	CLR;
	SPMZ ABII;
ABII:	NOP 0;
	XN TRUE;
	L 0;
	CLR;
	SPPZ ABIJ;
ABIJ:	NOP 0;
	INC 0;
	==D;
	NEGD;
	U(;
	);
	L 0;
	CLR;
	SPBN ABIK;
ABIK:	NOP 0;
	L 0;
	CLR;
	SPM ABIL;
ABIL:	NOP 0;
	O(;
	);
	= M 0.4;
	TAK;
	CC FC 43;
	+R;
	CLR;
	SQR;
	ZV Z 42;
	L 0;
	BTI;
	RND-;
	SQR;
	SET;
	XN M 0.4;
	NEGI;
	>R;
	*R;
	SQRT;
	L 0;
	CLR;
	SPBN ABIM;
ABIM:	NOP 0;
	==R;
	<I;
	L 0;
	CLR;
	SPBIN ABIN;
ABIN:	NOP 0;
	RLD;
	ACOS;
	L 0;
	CLR;
	SPZ ABIO;
ABIO:	NOP 0;
	CC FC 43;
	==D;
	+ 0;
	SAVE;
	*D;
	L 0;
	SE T 42;
	INVI;
	RLD;
	T MD 0;
	*R;
	SLW;
	TDB;
	LEAVE;
	SET;
	TAN;
	CLR;
	TAN;
	*D;
	L 0;
	BTD;
	ATAN;
	ASIN;
	CLR;
	X TRUE;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	TAD;
	==R;
	RRD;
	UW;
	UW;
	NOT;
	L 0;
	CLR;
	SPBNB ABIP;
ABIP:	NOP 0;
	SSI;
	ATAN;
	S M 0.4;
	SRW;
	L 0;
	CLR;
	SPBIN ABIQ;
ABIQ:	NOP 0;
	<=D;
	<=I;
	L 0;
	CLR;
	SPBIN ABIR;
ABIR:	NOP 0;
	L DW#16#85E95C6C;
	L 0;
	CLR;
	SPBI ABIS;
ABIS:	NOP 0;
	INC 0;
	U(;
	);
	PUSH;
	R M 0.4;
	XN FALSE;
	L 0;
	SV T 42;
	TAN;
	LN;
	SAVE;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	INC 0;
	LC MW 0;
	/I;
	ZV Z 42;
	BLD 0;
	S M 0.4;
	RRDA;
	X M 0.4;
	>I;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	L 0;
	BTI;
	ITB;
	/R;
	XN FALSE;
	SIN;
	L 0;
	CLR;
	SPBIN ABIT;
ABIT:	NOP 0;
	L 0;
	CLR;
	SPN ABIU;
ABIU:	NOP 0;
	NOP 0;
	TAR1;
	TAR;
	AUF DB 42;
	+I;
	L 0;
	BTD;
	NEGD;
	L 0;
	BTD;
	S M 0.4;
	CC FC 43;
	ZR Z 42;
	==I;
	ATAN;
	XOW;
	X M 0.4;
	UN M 0.4;
	ABS;
	>I;
	ON M 0.4;
	>=R;
	SRW;
	TAR2;
	SQRT;
	CC FC 43;
	SRD;
	L 0;
	CLR;
	SPO ABIV;
ABIV:	NOP 0;
	+D;
	ABS;
	L 0;
	CLR;
	SPO ABIW;
ABIW:	NOP 0;
	SET;
	<=I;
	<>D;
	ON M 0.4;
	ITD;
	<>I;
	X M 0.4;
	ITD;
	U FALSE;
	SLD;
	>=D;
	RND-;
	ATAN;
	UD;
	ITD;
	SET;
	L 0;
	CLR;
	SPO ABIX;
ABIX:	NOP 0;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	>=D;
	SLW;
	TAN;
	XN M 0.4;
	>I;
	<R;
	==R;
	LAR2;
	SRD;
	SSD;
	XN M 0.4;
	TAR;
	BLD 0;
	FR Z 42;
	INVI;
	L 0;
	CLR;
	SPBI ABIY;
ABIY:	NOP 0;
	INC 0;
	/R;
	UN(;
	);
	L 0;
	CLR;
	SPU ABIZ;
ABIZ:	NOP 0;
	O M 0.4;
	FP M 0.4;
	ACOS;
	SIN;
	RRD;
	+AR2;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	PUSH;
	L 0;
	CLR;
	SPBNB ABJA;
ABJA:	NOP 0;
	ON TRUE;
	SQR;
	SRD;
	L 0;
	SE T 42;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	SRD;
	TRUNC;
	ON(;
	);
	OW;
	X M 0.4;
	TAN;
	+AR1;
	L 0;
	CLR;
	SPN ABJB;
ABJB:	NOP 0;
	PUSH;
	X(;
	);
	TDB;
	SIN;
	SLW;
	>I;
	RRD;
	-I;
	T MD 0;
	ATAN;
	XN M 0.4;
	>R;
	L 0;
	CLR;
	SPBB ABJC;
ABJC:	NOP 0;
	DTB;
	SSD;
	-I;
	LAR1;
	TRUNC;
	L 0;
	SI T 42;
	TAW;
	NOP 0;
	L 0;
	CLR;
	LOOP ABJD;
ABJD:	NOP 0;
	CC FC 43;
	SSI;
	==D;
	L 0;
	CLR;
	SPBI ABJE;
ABJE:	NOP 0;
	*R;
	SIN;
	+D;
	SSD;
	>R;
	NEGI;
	L 0;
	CLR;
	SPBN ABJF;
ABJF:	NOP 0;
	SET;
	SLD;
	==D;
	<=R;
	INVI;
	<>R;
	UC FC 44;
	RLD;
	FN M 0.4;
	SIN;
	RRD;
	L 0;
	CLR;
	SPO ABJG;
ABJG:	NOP 0;
	RND+;
	NEGI;
	POP;
	U(;
	);
	X M 0.4;
	+ 0;
	ZR Z 42;
	+ 0;
	<>R;
	<=R;
	RRDA;
	O FALSE;
	L 0;
	CLR;
	LOOP ABJH;
ABJH:	NOP 0;
	ACOS;
	>I;
	RND;
	<I;
	ENT;
	TAD;
	SRD;
	ZR Z 42;
	+I;
	/I;
	XN TRUE;
	<=D;
	L 0;
	SE T 42;
	CC FC 43;
	FP M 0.4;
	U(;
	);
	LAR1;
	TAR2;
	<>I;
	==I;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	FP M 0.4;
	ENT;
	X FALSE;
	<R;
	<I;
	INVD;
	+D;
	<>R;
	L 0;
	CLR;
	SPBNB ABJI;
ABJI:	NOP 0;
	LAR2;
	L 0;
	SI T 42;
	RLDA;
	FN M 0.4;
	==R;
	-D;
	L 0;
	CLR;
	SPU ABJJ;
ABJJ:	NOP 0;
	>D;
	>=I;
	INVI;
	LAR1;
	SIN;
	UN M 0.4;
	FR Z 42;
	SLW;
	+I;
	L 0;
	CLR;
	SPBB ABJK;
ABJK:	NOP 0;
	L 0;
	SI T 42;
	>=R;
	NOT;
	TDB;
	/D;
	SIN;
	+D;
	FR Z 42;
	<=D;
	OW;
	COS;
	RND;
	>D;
	ASIN;
	LN;
	EXP;
	TAR2;
	L 0;
	SS T 42;
	+D;
	UN TRUE;
	>=D;
	O M 0.4;
	L 0;
	SS T 42;
	XN(;
	);
	NOT;
	L 0;
	CLR;
	LOOP ABJL;
ABJL:	NOP 0;
	L 0;
	CLR;
	SPN ABJM;
ABJM:	NOP 0;
	SQR;
	<R;
	ATAN;
	ON(;
	);
	/R;
	ON FALSE;
	+AR1;
	O(;
	);
	L 0;
	SA T 42;
	L 0;
	CLR;
	SPBI ABJN;
ABJN:	NOP 0;
	COS;
	SQR;
	PUSH;
	L 0;
	CLR;
	SPO ABJO;
ABJO:	NOP 0;
	L 0;
	CLR;
	SPN ABJP;
ABJP:	NOP 0;
	-I;
	O M 0.4;
	L 0;
	CLR;
	SPB ABJQ;
ABJQ:	NOP 0;
	OW;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	>=D;
	SQRT;
	T MD 0;
	INVD;
	XOD;
	LAR2;
	-I;
	SQRT;
	DTR;
	L 0;
	CLR;
	SPO ABJR;
ABJR:	NOP 0;
	NOT;
	ON TRUE;
	*R;
	<=I;
	L 0;
	SA T 42;
	OD;
	L 0;
	CLR;
	SPBN ABJS;
ABJS:	NOP 0;
	NEGD;
	CLR;
	L 0;
	SV T 42;
	PUSH;
	L 0;
	CLR;
	SPZ ABJT;
ABJT:	NOP 0;
	L 0;
	SA T 42;
	+I;
	<>R;
	XN M 0.4;
	UN TRUE;
	RND-;
	L 0;
	CLR;
	SPO ABJU;
ABJU:	NOP 0;
	TAN;
	L 0;
	SI T 42;
	<>I;
	ON(;
	);
	/D;
	ZR Z 42;
	L 0;
	SI T 42;
	/I;
	>=I;
	U(;
	);
	>=I;
	T MD 0;
	L 0;
	CLR;
	SPBIN ABJV;
ABJV:	NOP 0;
	DEC 0;
	UN M 0.4;
	TAR1;
	L 0;
	CLR;
	LOOP ABJW;
ABJW:	NOP 0;
	RND+;
	+AR2;
	LEAVE;
	XOW;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	TRUNC;
	*I;
	L 0;
	CLR;
	SPBIN ABJX;
ABJX:	NOP 0;
	L 0;
	CLR;
	SPBN ABJY;
ABJY:	NOP 0;
	DEC 0;
	>D;
	MOD;
	L 0;
	SA T 42;
	L DW#16#1AF026DF;
	L 0;
	SS T 42;
	BLD 0;
	DTB;
	+D;
	TAR1;
	FN M 0.4;
	>=D;
	TAN;
	LN;
	S M 0.4;
	CLR;
	ON(;
	);
	TAN;
	==D;
	SLW;
	NEGD;
	T MD 0;
	R M 0.4;
	*D;
	UW;
	SQRT;
	NOP 0;
	ENT;
	L 0;
	SS T 42;
	ABS;
	AUF DB 42;
	BLD 0;
	RLDA;
	TAN;
	LAR1;
	RLD;
	SIN;
	>R;
	<D;
	L 0;
	SI T 42;
	<=I;
	SRD;
	TAR2;
	==D;
	L 0;
	SE T 42;
	OW;
	<I;
	NEGD;
	TAR1;
	SLW;
	O FALSE;
	ENT;
	*D;
	<I;
	CC FC 43;
	EXP;
	<>I;
	<I;
	*D;
	DEC 0;
	L 0;
	CLR;
	SPBNB ABJZ;
ABJZ:	NOP 0;
	X FALSE;
	<I;
	/D;
	L 0;
	CLR;
	SPS ABKA;
ABKA:	NOP 0;
	/D;
	L 0;
	CLR;
	SPO ABKB;
ABKB:	NOP 0;
	L 0;
	CLR;
	SPBI ABKC;
ABKC:	NOP 0;
	SRD;
	UN FALSE;
	<D;
	NOP 0;
	COS;
	U(;
	);
	L 0;
	CLR;
	SPS ABKD;
ABKD:	NOP 0;
	L 0;
	CLR;
	SPBN ABKE;
ABKE:	NOP 0;
	NEGR;
	ITB;
	RLD;
	U M 0.4;
	>=I;
	TAK;
	*I;
	XN(;
	);
	XN TRUE;
	SLD;
	DEC 0;
	L 0;
	CLR;
	SPZ ABKF;
ABKF:	NOP 0;
	LEAVE;
	TAR;
	L 0;
	CLR;
	LOOP ABKG;
ABKG:	NOP 0;
	MOD;
	SLW;
	UC FC 44;
	==D;
	>D;
	L 0;
	SI T 42;
	TAR2;
	TAR;
	T MD 0;
	<=D;
	L 0;
	CLR;
	SPPZ ABKH;
ABKH:	NOP 0;
	SET;
	EXP;
	*R;
	TRUNC;
	ABS;
	L 0;
	CLR;
	LOOP ABKI;
ABKI:	NOP 0;
	OD;
	XN TRUE;
	L 0;
	CLR;
	SPB ABKJ;
ABKJ:	NOP 0;
	SET;
	<R;
	U TRUE;
	ENT;
	>=I;
	ENT;
	NOT;
	DTB;
	OD;
	+AR1;
	UN(;
	);
	INC 0;
	L 0;
	SA T 42;
	ITD;
	SLW;
	RRDA;
	X M 0.4;
	<I;
	XOW;
	ITB;
	X M 0.4;
	L 0;
	L 0;
	CLR;
	SPL ABKK;
ABKK:	NOP 0;
	INVD;
	FR Z 42;
	+AR2;
	LAR2;
	NOT;
	XOW;
	UC FC 44;
	L 0;
	CLR;
	SPM ABKL;
ABKL:	NOP 0;
	SQR;
	NOP 0;
	XN TRUE;
	XN M 0.4;
	+I;
	ATAN;
	ITB;
	SIN;
	U TRUE;
	+R;
	ZV Z 42;
	CLR;
	>I;
	FN M 0.4;
	OD;
	>=R;
	L 0;
	CLR;
	SPBB ABKM;
ABKM:	NOP 0;
	<D;
	ITB;
	ZV Z 42;
	SET;
	==R;
	L 0;
	CLR;
	SPS ABKN;
ABKN:	NOP 0;
	EXP;
	>=R;
	ON(;
	);
	L 0;
	CLR;
	SPPZ ABKO;
ABKO:	NOP 0;
	ITB;
	U FALSE;
	L 0;
	CLR;
	SPBIN ABKP;
ABKP:	NOP 0;
	*R;
	FN M 0.4;
	L 0;
	CLR;
	SPP ABKQ;
ABKQ:	NOP 0;
	<D;
	LN;
	L 0;
	CLR;
	SPM ABKR;
ABKR:	NOP 0;
	ZR Z 42;
	MOD;
	<I;
	UN(;
	);
	INVI;
	RND-;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	NOP 0;
	RND+;
	RRD;
	L 0;
	SV T 42;
	L 0;
	SI T 42;
	-R;
	>I;
	TDB;
	ON(;
	);
	L 0;
	CLR;
	SPP ABKS;
ABKS:	NOP 0;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	PUSH;
	EXP;
	X(;
	);
	SLD;
	UN TRUE;
	TRUNC;
	X M 0.4;
	TDB;
	PUSH;
	NOP 0;
	FN M 0.4;
	L DW#16#20257194;
	INC 0;
	EXP;
	T MD 0;
	NOT;
	RRDA;
	INVD;
	<D;
	/D;
	OD;
	>=R;
	FR Z 42;
	UD;
	TAN;
	POP;
	TAR;
	X FALSE;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	L 0;
	CLR;
	SPBNB ABKT;
ABKT:	NOP 0;
	<R;
	U M 0.4;
	ON(;
	);
	SLD;
	L 0;
	CLR;
	SPA ABKU;
ABKU:	NOP 0;
	SET;
	LC MW 0;
	+R;
	*I;
	NEGD;
	BLD 0;
	L 0;
	SV T 42;
	L 0;
	CLR;
	SPBN ABKV;
ABKV:	NOP 0;
	XN FALSE;
	XOW;
	LEAVE;
	XN(;
	);
	L 0;
	CLR;
	SPBIN ABKW;
ABKW:	NOP 0;
	SET;
	ABS;
	>=I;
	>D;
	POP;
	L 0;
	CLR;
	SPB ABKX;
ABKX:	NOP 0;
	ACOS;
	NEGI;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	L 0;
	SI T 42;
	L 0;
	CLR;
	SPP ABKY;
ABKY:	NOP 0;
	+I;
	ZR Z 42;
	TAR;
	L 0;
	CLR;
	SPA ABKZ;
ABKZ:	NOP 0;
	FR Z 42;
	L 0;
	CLR;
	SPM ABLA;
ABLA:	NOP 0;
	+I;
	NEGI;
	TAR2;
	SET;
	L 0;
	CLR;
	SPMZ ABLB;
ABLB:	NOP 0;
	X M 0.4;
	<>D;
	U M 0.4;
	UC FC 44;
	SLW;
	UN M 0.4;
	O M 0.4;
	<=R;
	LN;
	POP;
	RLD;
	/R;
	UD;
	S M 0.4;
	R M 0.4;
	UD;
	UN TRUE;
	>=I;
	/I;
	MOD;
	SET;
	+ 0;
	*R;
	L 0;
	BTI;
	O M 0.4;
	>=I;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	*D;
	DTB;
	LAR2;
	O M 0.4;
	TAW;
	XN M 0.4;
	L 0;
	CLR;
	SPB ABLC;
ABLC:	NOP 0;
	+ 0;
	DTB;
	CLR;
	L 0;
	CLR;
	SPO ABLD;
ABLD:	NOP 0;
	TAW;
	TRUNC;
	RRD;
	+D;
	ON TRUE;
	RRD;
	UC FC 44;
	NEGI;
	UN M 0.4;
	DTR;
	ABS;
	<>I;
	L 0;
	CLR;
	SPB ABLE;
ABLE:	NOP 0;
	INC 0;
	RRDA;
	RRD;
	>=R;
	PUSH;
	DTB;
	LEAVE;
	CC FC 43;
	LEAVE;
	<=R;
	X(;
	);
	NOP 0;
	<=I;
	X(;
	);
	<=I;
	ZR Z 42;
	INC 0;
	RND;
	L 0;
	SA T 42;
	L 0;
	L 0;
	CLR;
	SPL ABLF;
ABLF:	NOP 0;
	DTB;
	XN M 0.4;
	XOW;
	LC MW 0;
	ENT;
	TAR1;
	U M 0.4;
	ASIN;
	UN(;
	);
	L 0;
	CLR;
	SPM ABLG;
ABLG:	NOP 0;
	ACOS;
	EXP;
	L 0;
	L 0;
	CLR;
	SPL ABLH;
ABLH:	NOP 0;
	>=I;
	L 0;
	SS T 42;
	SSI;
	RRD;
	+D;
	L 0;
	SS T 42;
	XN FALSE;
	U(;
	);
	L 0;
	CLR;
	SPB ABLI;
ABLI:	NOP 0;
	COS;
	XOW;
	T MD 0;
	L 0;
	CLR;
	SPN ABLJ;
ABLJ:	NOP 0;
	UN M 0.4;
	/R;
	DTB;
	L 0;
	CLR;
	SPU ABLK;
ABLK:	NOP 0;
	S M 0.4;
	DEC 0;
	U FALSE;
	TAN;
	R M 0.4;
	L DW#16#326684FF;
	L 0;
	CLR;
	SPMZ ABLL;
ABLL:	NOP 0;
	L 0;
	CLR;
	SPZ ABLM;
ABLM:	NOP 0;
	X(;
	);
	SAVE;
	UN TRUE;
	ACOS;
	U TRUE;
	LC MW 0;
	L DW#16#1B9B71F0;
	RND-;
	+I;
	UN(;
	);
	L 0;
	CLR;
	SPU ABLN;
ABLN:	NOP 0;
	L 0;
	SA T 42;
	RND+;
	= M 0.4;
	SET;
	LAR1;
	SAVE;
	T MD 0;
	+AR2;
	>=I;
	NOT;
	ON(;
	);
	O TRUE;
	L 0;
	CLR;
	SPN ABLO;
ABLO:	NOP 0;
	X(;
	);
	<=I;
	ON(;
	);
	LAR2;
	O(;
	);
	L 0;
	CLR;
	SPO ABLP;
ABLP:	NOP 0;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	ACOS;
	X(;
	);
	FP M 0.4;
	O(;
	);
	ENT;
	UN(;
	);
	L 0;
	CLR;
	SPBI ABLQ;
ABLQ:	NOP 0;
	+R;
	SQR;
	SAVE;
	LN;
	TRUNC;
	SET;
	O M 0.4;
	TAR1;
	-R;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	ASIN;
	FN M 0.4;
	L 0;
	CLR;
	LOOP ABLR;
ABLR:	NOP 0;
	U TRUE;
	L 0;
	SS T 42;
	L 0;
	CLR;
	SPMZ ABLS;
ABLS:	NOP 0;
	NOP 0;
	DTB;
	==I;
	FP M 0.4;
	ON M 0.4;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	XN(;
	);
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	DTB;
	DEC 0;
	<=I;
	L 0;
	SV T 42;
	ZV Z 42;
	/I;
	COS;
	SLD;
	LAR2;
	L 0;
	BTD;
	FR Z 42;
	>D;
	XN FALSE;
	<=I;
	L 0;
	CLR;
	SPZ ABLT;
ABLT:	NOP 0;
	BLD 0;
	ATAN;
	L 0;
	SE T 42;
	+ 0;
	L 0;
	CLR;
	SPZ ABLU;
ABLU:	NOP 0;
	BLD 0;
	OD;
	>=D;
	>=D;
	SSD;
	L 0;
	CLR;
	SPZ ABLV;
ABLV:	NOP 0;
	CC FC 43;
	+I;
	L 0;
	CLR;
	SPBNB ABLW;
ABLW:	NOP 0;
	*D;
	O M 0.4;
	L 0;
	SS T 42;
	NOP 0;
	>=D;
	O(;
	);
	RND+;
	L 0;
	SI T 42;
	ENT;
	UN(;
	);
	TAN;
	-I;
	DTR;
	INVI;
	INVI;
	XN(;
	);
	+I;
	ITD;
	SLW;
	SSI;
	SET;
	L 0;
	CLR;
	SPMZ ABLX;
ABLX:	NOP 0;
	+AR2;
	LEAVE;
	L 0;
	CLR;
	SPU ABLY;
ABLY:	NOP 0;
	L 0;
	CLR;
	SPBIN ABLZ;
ABLZ:	NOP 0;
	COS;
	L 0;
	CLR;
	SPMZ ABMA;
ABMA:	NOP 0;
	>R;
	FP M 0.4;
	TAR1;
	X TRUE;
	TAW;
	U M 0.4;
	TAD;
	RND;
	SSI;
	NEGD;
	RND-;
	SLD;
	L 0;
	CLR;
	SPMZ ABMB;
ABMB:	NOP 0;
	MOD;
	INVD;
	SQR;
	L 0;
	BTD;
	UN M 0.4;
	+D;
	O M 0.4;
	= M 0.4;
	+ 0;
	UN FALSE;
	<D;
	L 0;
	CLR;
	SPBNB ABMC;
ABMC:	NOP 0;
	LAR1;
	DTB;
	BLD 0;
	+D;
	XN FALSE;
	DTR;
	DTR;
	L 0;
	CLR;
	SPBN ABMD;
ABMD:	NOP 0;
	<=R;
	TAW;
	AUF DB 42;
	<=R;
	L 0;
	CLR;
	LOOP ABME;
ABME:	NOP 0;
	PUSH;
	FR Z 42;
	L 0;
	BTI;
	DTR;
	XN M 0.4;
	L 0;
	BTI;
	AUF DB 42;
	FN M 0.4;
	XN M 0.4;
	>D;
	+R;
	<>I;
	L 0;
	CLR;
	LOOP ABMF;
ABMF:	NOP 0;
	NEGI;
	L 0;
	CLR;
	SPS ABMG;
ABMG:	NOP 0;
	TAR1;
	RND-;
	*D;
	/D;
	>=R;
	UW;
	ATAN;
	X(;
	);
	<I;
	<D;
	==D;
	ITD;
	DTB;
	XOW;
	MOD;
	/D;
	L 0;
	CLR;
	SPP ABMH;
ABMH:	NOP 0;
	SET;
	ASIN;
	FR Z 42;
	XN FALSE;
	UD;
	L 0;
	CLR;
	SPBI ABMI;
ABMI:	NOP 0;
	<=D;
	L 0;
	CLR;
	SPPZ ABMJ;
ABMJ:	NOP 0;
	L DW#16#CBAD3916;
	<=I;
	L 0;
	SV T 42;
	BLD 0;
	RLD;
	NEGI;
	S M 0.4;
	SSD;
	X(;
	);
	<R;
	L 0;
	SV T 42;
	*R;
	L 0;
	SV T 42;
	/D;
	RLDA;
	L 0;
	SS T 42;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	L 0;
	BTI;
	L 0;
	CLR;
	SPM ABMK;
ABMK:	NOP 0;
	/D;
	UW;
	SLD;
	RRD;
	SLW;
	TDB;
	+AR2;
	SQR;
	BLD 0;
	ON FALSE;
	TAW;
	INVI;
	TAR;
	RND+;
	ABS;
	NEGR;
	L 0;
	CLR;
	SPS ABML;
ABML:	NOP 0;
	TAN;
	MOD;
	DEC 0;
	<>R;
	/D;
	ZV Z 42;
	TAK;
	NOT;
	<>D;
	NOT;
	L 0;
	CLR;
	SPBI ABMM;
ABMM:	NOP 0;
	LAR2;
	L 0;
	SS T 42;
	/I;
	RND;
	BLD 0;
	X TRUE;
	L 0;
	SE T 42;
	L 0;
	CLR;
	LOOP ABMN;
ABMN:	NOP 0;
	ASIN;
	TAR;
	SSI;
	ACOS;
	EXP;
	*D;
	RLDA;
	L 0;
	CLR;
	SPP ABMO;
ABMO:	NOP 0;
	L 0;
	CLR;
	SPA ABMP;
ABMP:	NOP 0;
	+R;
	U FALSE;
	LAR2;
	TRUNC;
	AUF DB 42;
	R M 0.4;
	+ 0;
	NOT;
	L 0;
	CLR;
	SPBI ABMQ;
ABMQ:	NOP 0;
	RRDA;
	L 0;
	SE T 42;
	XOD;
	S M 0.4;
	L 0;
	L 0;
	CLR;
	SPL ABMR;
ABMR:	NOP 0;
	RND;
	FN M 0.4;
	<I;
	= M 0.4;
	+D;
	ON FALSE;
	L 0;
	CLR;
	SPU ABMS;
ABMS:	NOP 0;
	DTR;
	L 0;
	CLR;
	SPMZ ABMT;
ABMT:	NOP 0;
	LC MW 0;
	L 0;
	CLR;
	SPO ABMU;
ABMU:	NOP 0;
	L 0;
	L 0;
	CLR;
	SPL ABMV;
ABMV:	NOP 0;
	ITD;
	CC FC 43;
	>D;
	XOD;
	ZR Z 42;
	O M 0.4;
	L 0;
	CLR;
	SPBIN ABMW;
ABMW:	NOP 0;
	L 0;
	CLR;
	SPBN ABMX;
ABMX:	NOP 0;
	-I;
	SQRT;
	SQRT;
	+AR2;
	ON M 0.4;
	SSD;
	L 0;
	SE T 42;
	<=D;
	ABS;
	RND;
	RND;
	NEGI;
	SLW;
	TRUNC;
	L 0;
	SS T 42;
	NOP 0;
	PUSH;
	SSI;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	+I;
	NOT;
	L 0;
	CLR;
	SPN ABMY;
ABMY:	NOP 0;
	ITD;
	ASIN;
	SIN;
	NEGI;
	LAR1;
	TAR;
	POP;
	UN TRUE;
	>D;
	+AR1;
	<=I;
	L 0;
	CLR;
	SPS ABMZ;
ABMZ:	NOP 0;
	O M 0.4;
	RLDA;
	/I;
	L 0;
	CLR;
	LOOP ABNA;
ABNA:	NOP 0;
	TAD;
	COS;
	TAN;
	SQRT;
	UD;
	L 0;
	CLR;
	SPBIN ABNB;
ABNB:	NOP 0;
	L 0;
	CLR;
	SPPZ ABNC;
ABNC:	NOP 0;
	NOP 0;
	XN M 0.4;
	INC 0;
	O FALSE;
	==R;
	L 0;
	CLR;
	SPMZ ABND;
ABND:	NOP 0;
	INC 0;
	CC FC 43;
	UC FC 44;
	DEC 0;
	/R;
	+R;
	INVD;
	/R;
	X(;
	);
	XOW;
	-R;
	ITD;
	SLW;
	==I;
	L 0;
	CLR;
	SPMZ ABNE;
ABNE:	NOP 0;
	INC 0;
	TAR;
	L 0;
	CLR;
	SPO ABNF;
ABNF:	NOP 0;
	CLR;
	>=R;
	FP M 0.4;
	PUSH;
	L 0;
	BTI;
	O TRUE;
	U FALSE;
	DTR;
	XN(;
	);
	-R;
	L 0;
	CLR;
	SPBN ABNG;
ABNG:	NOP 0;
	INVD;
	TRUNC;
	L 0;
	CLR;
	SPBNB ABNH;
ABNH:	NOP 0;
	UW;
	XN(;
	);
	TAR1;
	O(;
	);
	*D;
	L 0;
	SS T 42;
	O M 0.4;
	>=R;
	L 0;
	CLR;
	SPPZ ABNI;
ABNI:	NOP 0;
	LN;
	/R;
	<>R;
	<>I;
	==D;
	UD;
	COS;
	SRW;
	XN(;
	);
	*R;
	INVD;
	==D;
	INVD;
	L 0;
	CLR;
	SPZ ABNJ;
ABNJ:	NOP 0;
	ACOS;
	SLW;
	<>R;
	CC FC 43;
	+AR1;
	L 0;
	CLR;
	SPZ ABNK;
ABNK:	NOP 0;
	NOP 0;
	INVI;
	RRDA;
	TAR2;
	L 0;
	L 0;
	CLR;
	SPL ABNL;
ABNL:	NOP 0;
	INVI;
	UN M 0.4;
	<D;
	T MD 0;
	X(;
	);
	SQR;
	CC FC 43;
	L DW#16#869E8836;
	INC 0;
	RLD;
	TAR2;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	+AR1;
	X FALSE;
	L 0;
	CLR;
	SPBB ABNM;
ABNM:	NOP 0;
	TAR1;
	-I;
	L 0;
	CLR;
	SPBIN ABNN;
ABNN:	NOP 0;
	/R;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	<=R;
	SIN;
	L DW#16#6E9C92BA;
	-R;
	ITB;
	INC 0;
	SAVE;
	/R;
	XN FALSE;
	<>R;
	L 0;
	L 0;
	CLR;
	SPL ABNO;
ABNO:	NOP 0;
	UD;
	L 0;
	CLR;
	SPBNB ABNP;
ABNP:	NOP 0;
	XN(;
	);
	NEGR;
	RRD;
	LN;
	PUSH;
	>=I;
	*D;
	R M 0.4;
	FP M 0.4;
	L 0;
	SI T 42;
	L 0;
	CLR;
	SPPZ ABNQ;
ABNQ:	NOP 0;
	EXP;
	TAR;
	<R;
	LC MW 0;
	NEGI;
	L 0;
	SI T 42;
	XN TRUE;
	U FALSE;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	+R;
	+I;
	SQR;
	DTB;
	ABS;
	ON FALSE;
	LC MW 0;
	>I;
	<>D;
	L 0;
	CLR;
	SPPZ ABNR;
ABNR:	NOP 0;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	SRD;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	XN(;
	);
	NOT;
	TAK;
	FR Z 42;
	LAR1;
	>D;
	SSD;
	L 0;
	CLR;
	SPB ABNS;
ABNS:	NOP 0;
	>R;
	>=R;
	X M 0.4;
	UC FC 44;
	FN M 0.4;
	L 0;
	BTI;
	L 0;
	CLR;
	SPBI ABNT;
ABNT:	NOP 0;
	>=I;
	XOW;
	/R;
	>=R;
	R M 0.4;
	O M 0.4;
	L 0;
	CLR;
	SPA ABNU;
ABNU:	NOP 0;
	==R;
	LAR1;
	+ 0;
	L 0;
	BTI;
	NEGR;
	O FALSE;
	LAR2;
	U(;
	);
	L 0;
	SA T 42;
	FP M 0.4;
	*R;
	L 0;
	CLR;
	SPS ABNV;
ABNV:	NOP 0;
	LAR2;
	UN(;
	);
	SET;
	UN M 0.4;
	U(;
	);
	MOD;
	INVI;
	L DW#16#3D10FA95;
	CLR;
	X M 0.4;
	COS;
	UN FALSE;
	L 0;
	CLR;
	LOOP ABNW;
ABNW:	NOP 0;
	DTB;
	X(;
	);
	TAW;
	SAVE;
	<R;
	<R;
	XN TRUE;
	L 0;
	SE T 42;
	==I;
	L 0;
	CLR;
	SPPZ ABNX;
ABNX:	NOP 0;
	L 0;
	CLR;
	SPM ABNY;
ABNY:	NOP 0;
	ENT;
	ITD;
	NEGI;
	OD;
	ABS;
	ASIN;
	<I;
	TRUNC;
	NEGD;
	==I;
	+ 0;
	L 0;
	CLR;
	SPM ABNZ;
ABNZ:	NOP 0;
	<=R;
	ON M 0.4;
	SQR;
	L 0;
	CLR;
	SPN ABOA;
ABOA:	NOP 0;
	ON M 0.4;
	*R;
	NEGD;
	TAR2;
	TAW;
	X(;
	);
	L 0;
	CLR;
	SPB ABOB;
ABOB:	NOP 0;
	*D;
	XN FALSE;
	NEGR;
	LN;
	L 0;
	CLR;
	SPO ABOC;
ABOC:	NOP 0;
	SET;
	RLDA;
	FP M 0.4;
	UD;
	INC 0;
	>=R;
	LC MW 0;
	SAVE;
	SET;
	L 0;
	CLR;
	SPPZ ABOD;
ABOD:	NOP 0;
	*R;
	<>D;
	L 0;
	CLR;
	SPU ABOE;
ABOE:	NOP 0;
	<=R;
	L 0;
	CLR;
	SPP ABOF;
ABOF:	NOP 0;
	SLD;
	XN(;
	);
	L 0;
	CLR;
	SPU ABOG;
ABOG:	NOP 0;
	X M 0.4;
	UC FC 44;
	BLD 0;
	T MD 0;
	+R;
	L 0;
	SV T 42;
	TRUNC;
	RRDA;
	NOP 0;
	ON M 0.4;
	TRUNC;
	XN M 0.4;
	>=I;
	L 0;
	CLR;
	SPZ ABOH;
ABOH:	NOP 0;
	RND+;
	ASIN;
	FR Z 42;
	S M 0.4;
	ON(;
	);
	>D;
	/D;
	RLDA;
	L 0;
	CLR;
	SPBI ABOI;
ABOI:	NOP 0;
	INVI;
	<=D;
	MOD;
	INVD;
	ON FALSE;
	SET;
	LAR2;
	L 0;
	CLR;
	SPMZ ABOJ;
ABOJ:	NOP 0;
	<>D;
	L 0;
	CLR;
	SPB ABOK;
ABOK:	NOP 0;
	L 0;
	CLR;
	SPP ABOL;
ABOL:	NOP 0;
	X TRUE;
	L 0;
	CLR;
	SPBB ABOM;
ABOM:	NOP 0;
	U FALSE;
	L 0;
	CLR;
	SPMZ ABON;
ABON:	NOP 0;
	+I;
	FR Z 42;
	INVD;
	OD;
	UN(;
	);
	L DW#16#DF69A560;
	L 0;
	SA T 42;
	L 0;
	CLR;
	SPM ABOO;
ABOO:	NOP 0;
	ITB;
	LAR2;
	UN M 0.4;
	X(;
	);
	RLD;
	XN(;
	);
	DTB;
	UN(;
	);
	<D;
	INVD;
	<=I;
	CLR;
	<=R;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	TAK;
	INVD;
	RND+;
	L 0;
	SI T 42;
	S M 0.4;
	ASIN;
	SSI;
	L 0;
	CLR;
	SPZ ABOP;
ABOP:	NOP 0;
	<R;
	DTR;
	FR Z 42;
	TAN;
	L 0;
	BTI;
	UC FC 44;
	L DW#16#4D980202;
	+AR1;
	T MD 0;
	INVI;
	L 0;
	CLR;
	SPA ABOQ;
ABOQ:	NOP 0;
	SLD;
	S M 0.4;
	+D;
	ABS;
	MOD;
	<R;
	SSD;
	LAR1;
	TAN;
	L 0;
	SI T 42;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	ACOS;
	==R;
	SLD;
	XN M 0.4;
	+R;
	ASIN;
	NOT;
	L 0;
	CLR;
	SPBIN ABOR;
ABOR:	NOP 0;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	UD;
	==R;
	PUSH;
	<=R;
	ZV Z 42;
	+R;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	L 0;
	CLR;
	SPS ABOS;
ABOS:	NOP 0;
	TAR1;
	L 0;
	CLR;
	SPBN ABOT;
ABOT:	NOP 0;
	MOD;
	ENT;
	UC FC 44;
	SLD;
	= M 0.4;
	L 0;
	CLR;
	SPU ABOU;
ABOU:	NOP 0;
	<>D;
	SSD;
	DTR;
	==R;
	ITD;
	UN M 0.4;
	ON M 0.4;
	RRDA;
	/D;
	RLD;
	SQRT;
	SIN;
	ABS;
	/D;
	-R;
	RLD;
	L 0;
	CLR;
	SPS ABOV;
ABOV:	NOP 0;
	NOP 0;
	= M 0.4;
	EXP;
	ON FALSE;
	-R;
	LEAVE;
	>R;
	DTB;
	ATAN;
	ZV Z 42;
	*I;
	L 0;
	SV T 42;
	RLD;
	*D;
	O(;
	);
	-R;
	TAN;
	L DW#16#3E0AD66D;
	O TRUE;
	UN FALSE;
	ZR Z 42;
	CC FC 43;
	TAR1;
	>=D;
	ZV Z 42;
	L DW#16#D76D9612;
	ON M 0.4;
	>I;
	CLR;
	-R;
	ABS;
	NOP 0;
	S M 0.4;
	L 0;
	SS T 42;
	ITD;
	TAN;
	<R;
	ASIN;
	LC MW 0;
	L 0;
	CLR;
	SPO ABOW;
ABOW:	NOP 0;
	RRDA;
	XOW;
	+R;
	NOP 0;
	L 0;
	CLR;
	SPS ABOX;
ABOX:	NOP 0;
	LN;
	SET;
	==I;
	DEC 0;
	-I;
	<D;
	TDB;
	NEGI;
	ABS;
	L 0;
	CLR;
	SPS ABOY;
ABOY:	NOP 0;
	UN M 0.4;
	>=R;
	RLD;
	U M 0.4;
	SAVE;
	XN(;
	);
	SIN;
	UW;
	SIN;
	L 0;
	CLR;
	SPBB ABOZ;
ABOZ:	NOP 0;
	ACOS;
	>=R;
	L 0;
	BTI;
	/D;
	L 0;
	BTD;
	<>D;
	DTR;
	SRD;
	ITB;
	RRDA;
	<>I;
	TAR;
	INC 0;
	NEGD;
	L 0;
	BTD;
	INVI;
	ON(;
	);
	ITB;
	DTB;
	ZR Z 42;
	EXP;
	LAR1;
	==I;
	<R;
	S M 0.4;
	L 0;
	CLR;
	SPBI ABPA;
ABPA:	NOP 0;
	NOT;
	MOD;
	>=I;
	L 0;
	L 0;
	CLR;
	SPL ABPB;
ABPB:	NOP 0;
	X(;
	);
	+I;
	UN FALSE;
	SRW;
	SRD;
	FN M 0.4;
	O M 0.4;
	ON(;
	);
	TDB;
	UN M 0.4;
	BLD 0;
	X FALSE;
	NEGD;
	L 0;
	SA T 42;
	UN M 0.4;
	MOD;
	CC FC 43;
	L 0;
	SA T 42;
	TDB;
	SRD;
	SLW;
	L 0;
	CLR;
	LOOP ABPC;
ABPC:	NOP 0;
	CC FC 43;
	ASIN;
	L 0;
	CLR;
	LOOP ABPD;
ABPD:	NOP 0;
	*D;
	+I;
	L 0;
	CLR;
	SPN ABPE;
ABPE:	NOP 0;
	RND-;
	+D;
	SQR;
	MOD;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	O(;
	);
	+ 0;
	L 0;
	CLR;
	SPMZ ABPF;
ABPF:	NOP 0;
	FN M 0.4;
	U M 0.4;
	TAR1;
	SQR;
	>D;
	U FALSE;
	OW;
	L 0;
	CLR;
	SPB ABPG;
ABPG:	NOP 0;
	L DW#16#5E516BF8;
	SLW;
	L 0;
	SE T 42;
	LN;
	ITD;
	U M 0.4;
	L 0;
	CLR;
	SPM ABPH;
ABPH:	NOP 0;
	X M 0.4;
	+D;
	XN TRUE;
	LAR2;
	TRUNC;
	UC FC 44;
	SRD;
	SQR;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	S M 0.4;
	*I;
	ASIN;
	SLW;
	FN M 0.4;
	-R;
	L 0;
	CLR;
	SPBI ABPI;
ABPI:	NOP 0;
	UC FC 44;
	DTB;
	<D;
	L 0;
	SA T 42;
	DEC 0;
	L 0;
	SI T 42;
	O FALSE;
	RLDA;
	SET;
	L 0;
	CLR;
	SPO ABPJ;
ABPJ:	NOP 0;
	TAK;
	SSI;
	>=R;
	T MD 0;
	>I;
	SLD;
	OD;
	RND-;
	FR Z 42;
	NEGD;
	>=R;
	SET;
	==I;
	ATAN;
	UN FALSE;
	L 0;
	CLR;
	SPPZ ABPK;
ABPK:	NOP 0;
	-R;
	L 0;
	CLR;
	SPB ABPL;
ABPL:	NOP 0;
	TAW;
	ZV Z 42;
	SLW;
	>=I;
	<>D;
	XOW;
	RLD;
	CLR;
	L 0;
	CLR;
	SPU ABPM;
ABPM:	NOP 0;
	TAD;
	+AR1;
	SET;
	X(;
	);
	+I;
	MOD;
	+R;
	ENT;
	ATAN;
	TRUNC;
	TAD;
	ZR Z 42;
	>I;
	L 0;
	CLR;
	SPBNB ABPN;
ABPN:	NOP 0;
	SET;
	<>I;
	SET;
	+I;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	ITD;
	>I;
	DEC 0;
	*D;
	<=I;
	L 0;
	CLR;
	SPN ABPO;
ABPO:	NOP 0;
	+R;
	+AR1;
	U M 0.4;
	L 0;
	CLR;
	SPZ ABPP;
ABPP:	NOP 0;
	ON(;
	);
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	UD;
	ITD;
	*R;
	TAN;
	L 0;
	CLR;
	SPP ABPQ;
ABPQ:	NOP 0;
	-D;
	<=I;
	L 0;
	SA T 42;
	CC FC 43;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	TAW;
	==I;
	ABS;
	O M 0.4;
	UD;
	TAR2;
	L 0;
	CLR;
	SPN ABPR;
ABPR:	NOP 0;
	>=D;
	L 0;
	CLR;
	SPBI ABPS;
ABPS:	NOP 0;
	TAW;
	RLDA;
	TAR1;
	>=D;
	SET;
	L 0;
	CLR;
	SPBN ABPT;
ABPT:	NOP 0;
	>=D;
	O TRUE;
	L 0;
	CLR;
	SPZ ABPU;
ABPU:	NOP 0;
	RRDA;
	>=I;
	L 0;
	L 0;
	CLR;
	SPL ABPV;
ABPV:	NOP 0;
	DEC 0;
	SRW;
	NEGR;
	RRD;
	L 0;
	CLR;
	SPBNB ABPW;
ABPW:	NOP 0;
	MOD;
	ON(;
	);
	L 0;
	CLR;
	SPU ABPX;
ABPX:	NOP 0;
	==R;
	NEGI;
	TAD;
	UN(;
	);
	L 0;
	BTI;
	SRD;
	/R;
	L 0;
	CLR;
	SPBIN ABPY;
ABPY:	NOP 0;
	<>R;
	XN M 0.4;
	TAK;
	/R;
	L 0;
	CLR;
	LOOP ABPZ;
ABPZ:	NOP 0;
	TAN;
	SLW;
	*I;
	/R;
	/R;
	= M 0.4;
	OW;
	L 0;
	CLR;
	SPBN ABQA;
ABQA:	NOP 0;
	L 0;
	CLR;
	SPBN ABQB;
ABQB:	NOP 0;
	DTB;
	TAK;
	/R;
	SAVE;
	==D;
	L 0;
	CLR;
	SPM ABQC;
ABQC:	NOP 0;
	+AR2;
	UN(;
	);
	L 0;
	CLR;
	SPO ABQD;
ABQD:	NOP 0;
	TAR2;
	>R;
	+AR1;
	>D;
	LAR2;
	SLD;
	L 0;
	CLR;
	SPBNB ABQE;
ABQE:	NOP 0;
	>=D;
	NEGI;
	NEGR;
	DTR;
	O M 0.4;
	+D;
	+AR1;
	FP M 0.4;
	>=D;
	MOD;
	ASIN;
	>=R;
	O(;
	);
	SAVE;
	+ 0;
	SLW;
	L 0;
	BTI;
	UN(;
	);
	<I;
	L 0;
	SE T 42;
	L 0;
	CLR;
	LOOP ABQF;
ABQF:	NOP 0;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	ATAN;
	<=D;
	SQRT;
	FR Z 42;
	O FALSE;
	RND-;
	ABS;
	RLD;
	L 0;
	CLR;
	SPO ABQG;
ABQG:	NOP 0;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	<=R;
	MOD;
	SET;
	MCR(;
	MCRA;
	MCRD;
	)MCR;
	+R;
	L 0;
	L 0;
	CLR;
	SPL ABQH;
ABQH:	NOP 0;
	LAR2;
	*D;
	O M 0.4;
	<I;
	>I;
	NOT;
	>=I;
	RLD;
	L 0;
	SV T 42;
	TAD;
	XN M 0.4;
	NOP 0;
	DEC 0;
	DEC 0;
	SRW;
	L 0;
	L 0;
	CLR;
	SPL ABQI;
ABQI:	NOP 0;
	SAVE;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	ITB;
	-R;
	SLD;
	ATAN;
	L 0;
	CLR;
	SPBIN ABQJ;
ABQJ:	NOP 0;
	DEC 0;
	<=I;
	FN M 0.4;
	L 0;
	CLR;
	SPPZ ABQK;
ABQK:	NOP 0;
	X(;
	);
	UD;
	L 0;
	BTD;
	SQRT;
	XN M 0.4;
	/R;
	POP;
	UD;
	OW;
	RLD;
	X(;
	);
	L 0;
	SS T 42;
	BLD 0;
	UD;
	>=I;
	NEGI;
	<I;
	ITB;
	SET;
	ITB;
	UN M 0.4;
	POP;
	T MD 0;
	L 0;
	CLR;
	SPN ABQL;
ABQL:	NOP 0;
	>=I;
	X FALSE;
	+AR1;
	INVD;
	>R;
	SET;
	ENT;
	ZV Z 42;
	O FALSE;
	>=I;
	L 0;
	SI T 42;
	L 0;
	CLR;
	SPBIN ABQM;
ABQM:	NOP 0;
	-D;
	XOD;
	>=R;
	TAN;
	U M 0.4;
	L DW#16#4CF41EDD;
	L 0;
	SS T 42;
	L 0;
	CLR;
	SPBI ABQN;
ABQN:	NOP 0;
	XOW;
	LAR2;
	>D;
	+AR1;
	RLD;
	L 0;
	CLR;
	SPN ABQO;
ABQO:	NOP 0;
	L 0;
	SA T 42;
	/I;
	UC FC 44;
	UD;
	L 0;
	SV T 42;
	NEGI;
	FN M 0.4;
	XN FALSE;
	ON FALSE;
	<D;
	L 0;
	CLR;
	SPBIN ABQP;
ABQP:	NOP 0;
	NEGR;
	<>D;
	CC FC 43;
	PUSH;
	NEGR;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	+ 0;
	L 0;
	CLR;
	SPB ABQQ;
ABQQ:	NOP 0;
	<=I;
	TAN;
	R M 0.4;
	TAK;
	ZV Z 42;
	ZR Z 42;
	+R;
	>R;
	SQR;
	TAR1;
	NOT;
	ZV Z 42;
	TAN;
	<D;
	UD;
	INVD;
	= M 0.4;
	TDB;
	DTB;
	/D;
	LEAVE;
	L 0;
	SV T 42;
	CC FC 43;
	>R;
	COS;
	==R;
	L 0;
	CLR;
	SPN ABQR;
ABQR:	NOP 0;
	ATAN;
	+R;
	U FALSE;
	R M 0.4;
	L 0;
	CLR;
	SPA ABQS;
ABQS:	NOP 0;
	>=I;
	XOW;
	<>I;
	TAK;
	EXP;
	X(;
	);
	L 0;
	CLR;
	SPMZ ABQT;
ABQT:	NOP 0;
	SET;
	+D;
	L 0;
	CLR;
	SPU ABQU;
ABQU:	NOP 0;
	L 0;
	CLR;
	SPA ABQV;
ABQV:	NOP 0;
	>=D;
	TAD;
	L 0;
	L 0;
	CLR;
	SPL ABQW;
ABQW:	NOP 0;
	O M 0.4;
	FN M 0.4;
	MOD;
	TAW;
	MOD;
	FP M 0.4;
	>=I;
	<=R;
	UW;
	L 0;
	CLR;
	SPS ABQX;
ABQX:	NOP 0;
	NOP 0;
	RLD;
	SAVE;
	OW;
	*I;
	DEC 0;
	L 0;
	CLR;
	SPBN ABQY;
ABQY:	NOP 0;
	PUSH;
	L 0;
	CLR;
	SPA ABQZ;
ABQZ:	NOP 0;
	UC FC 44;
	FN M 0.4;
	U(;
	);
	>=R;
	L 0;
	CLR;
	SPP ABRA;
ABRA:	NOP 0;
	*R;
	ITB;
	-I;
	XOW;
	PUSH;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	SQRT;
	SRW;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	<=I;
	ZR Z 42;
	O M 0.4;
	L 0;
	SE T 42;
	==R;
	<=I;
	<D;
	MOD;
	INC 0;
	TDB;
	UN(;
	);
	*D;
	L DW#16#75318081;
	LAR1;
	/I;
	SSI;
	RRDA;
	L 0;
	CLR;
	SPBB ABRB;
ABRB:	NOP 0;
	L 0;
	L 0;
	CLR;
	SPL ABRC;
ABRC:	NOP 0;
	ASIN;
	L 0;
	SA T 42;
	RND;
	L 0;
	CLR;
	SPS ABRD;
ABRD:	NOP 0;
	SET;
	L 0;
	CLR;
	SPS ABRE;
ABRE:	NOP 0;
	EXP;
	L 0;
	CLR;
	SPN ABRF;
ABRF:	NOP 0;
	CLR;
	S M 0.4;
	R M 0.4;
	RND-;
	CLR;
	<R;
	+AR1;
	O(;
	);
	NOT;
	L 0;
	CLR;
	SPBB ABRG;
ABRG:	NOP 0;
	PUSH;
	RRD;
	O M 0.4;
	TAN;
	L 0;
	SV T 42;
	<>D;
	SRW;
	RLDA;
	L 0;
	SE T 42;
	XOW;
	>=I;
	SQRT;
	ON M 0.4;
	ITD;
	UN M 0.4;
	TAN;
	XOW;
	-I;
	FR Z 42;
	OW;
	UC FC 44;
	X TRUE;
	>=R;
	UW;
	TAD;
	<=R;
	R M 0.4;
	-D;
	<>D;
	L 0;
	SE T 42;
	/I;
	UN(;
	);
	TAN;
	RRD;
	+R;
	>=R;
	/D;
	<>I;
	L 0;
	CLR;
	LOOP ABRH;
ABRH:	NOP 0;
	L DW#16#DB992F51;
	L 0;
	CLR;
	SPBNB ABRI;
ABRI:	NOP 0;
	L 0;
	CLR;
	SPBIN ABRJ;
ABRJ:	NOP 0;
	SLD;
	L 0;
	CLR;
	SPBI ABRK;
ABRK:	NOP 0;
	AUF DB 42;
	NEGD;
	U M 0.4;
	INC 0;
	/R;
	NEGR;
	L 0;
	CLR;
	SPS ABRL;
ABRL:	NOP 0;
	L 0;
	SE T 42;
	ON TRUE;
	SRD;
	O(;
	);
	+ 0;
	UN M 0.4;
	TAR2;
	L 0;
	CLR;
	SPMZ ABRM;
ABRM:	NOP 0;
	L 0;
	CLR;
	SPBIN ABRN;
ABRN:	NOP 0;
	/I;
	==I;
	UN M 0.4;
	*I;
	L 0;
	BTD;
	SQR;
	/I;
	O M 0.4;
	FN M 0.4;
	ACOS;
	RLD;
	DTR;
	NOT;
	OW;
	L 0;
	SE T 42;
	==R;
	LN;
	>=I;
	SRD;
	UN M 0.4;
	==R;
	LC MW 0;
	TAD;
	SSD;
	ABS;
	/D;
	L 0;
	CLR;
	SPBIN ABRO;
ABRO:	NOP 0;
	-D;
	ASIN;
	ITB;
	UD;
	TDB;
	==I;
	LAR1;
	LAR1;
	>R;
	>D;
	/I;
	ATAN;
	UN M 0.4;
	+ 0;
	DTR;
	<>I;
	ITD;
	L 0;
	CLR;
	SPBN ABRP;
ABRP:	NOP 0;
	X FALSE;
	ABS;
	COS;
	L 0;
	CLR;
	SPMZ ABRQ;
ABRQ:	NOP 0;
	O FALSE;
	DTR;
	SRW;
	TDB;
	<I;
	COS;
	RLD;
	TAK;
	RRD;
	<=I;
	L 0;
	CLR;
	SPPZ ABRR;
ABRR:	NOP 0;
	SQR;
	RRDA;
	*R;
	==D;
	<>I;
	==I;
	XN M 0.4;
	<=I;
	==R;
	-I;
	RRDA;
	ON M 0.4;
	RND+;
	UN(;
	);
	+I;
	ASIN;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	CALL FB 45, DB 45;
	O M 0.4;
	ATAN;
	SRW;
	L 0;
	CLR;
	SPBNB ABRS;
ABRS:	NOP 0;
	L 0;
	CLR;
	SPBN ABRT;
ABRT:	NOP 0;
	SRD;
	NOT;
	ASIN;
	L DW#16#9E1BE56D;
	L 0;
	SV T 42;
	L 0;
	BTD;
	L DW#16#B371D64D;
	ASIN;
	DTR;
	SLW;
	FP M 0.4;
	RRDA;
	L MW 50;
	+ 1;
	T MW 50;
	T AW 0;
	ITB;
	ITD;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	<=D;
	RND;
	<I;
	==D;
	SQR;
	ON TRUE;
	DTB;
	>=D;
	ASIN;
	X M 0.4;
	INVI;
	CLR;
	UN(;
	);
	+R;
	EXP;
	UW;
	L 0;
	CLR;
	SPS ABRU;
ABRU:	NOP 0;
	TRUNC;
	TAW;
	L 0;
	CLR;
	LOOP ABRV;
ABRV:	NOP 0;
	ASIN;
	SRW;
	ON(;
	);
	L 0;
	SV T 42;
	ASIN;
	UN(;
	);
	L 0;
	CLR;
	SPO ABRW;
ABRW:	NOP 0;
	<>I;
	TDB;
	-D;
	L 0;
	CLR;
	SPB ABRX;
ABRX:	NOP 0;
	*I;
	COS;
	L DW#16#0C2CA7FA;
	X FALSE;
	UN(;
	);
	L 0;
	CLR;
	SPM ABRY;
ABRY:	NOP 0;
	NEGD;
	L 0;
	CLR;
	SPBB ABRZ;
ABRZ:	NOP 0;
	SSD;
	L 0;
	CLR;
	SPB ABSA;
ABSA:	NOP 0;
	UC FC 44;
	FN M 0.4;
	ACOS;
	L 0;
	BTD;
	LC MW 0;
	RLD;
	-D;
	L 0;
	CLR;
	SPU ABSB;
ABSB:	NOP 0;
	L 0;
	CLR;
	SPO ABSC;
ABSC:	NOP 0;
	<>I;
	SAVE;
	ON M 0.4;
	PUSH;
	==D;
	L 0;
	CLR;
	SPMZ ABSD;
ABSD:	NOP 0;
	+D;
	+D;
	NOP 0;
	OW;
	CC FC 43;
	/D;
	RND+;
	L 0;
	L 0;
	CLR;
	SPL ABSE;
ABSE:	NOP 0;
	NEGI;
	BLD 0;
	-R;
	SET;
	==I;
	==D;
	CC FC 43;
	<I;
	X FALSE;
	DTB;
	T MD 0;
	FN M 0.4;
	R M 0.4;
	XOD;
	+I;
	L 0;
	CLR;
	SPO ABSF;
ABSF:	NOP 0;
	SLW;
	INVI;
	XOW;
	==R;
	XN FALSE;
	DTB;
	COS;
	TAK;
	LC MW 0;
	ENT;
	-I;
	-D;
	T MD 0;
	<I;
	ATAN;
	XN(;
	);
	SLD;
	COS;
	UW;
	RRDA;
	XN M 0.4;
	<R;
	SET;
	L 0;
	L 0;
	CLR;
	SPL ABSG;
ABSG:	NOP 0;
	==D;
	L 0;
	CLR;
	SPBNB ABSH;
ABSH:	NOP 0;
	XN FALSE;
	ITD;
	ABS;
	RRD;
	XOW;
	L 0;
	SE T 42;
	R M 0.4;
	<R;
	LAR1;
	L 0;
	SV T 42;
	-R;
	ENT;
	*R;
	SQR;
	UC FC 44;
	L 0;
	CLR;
	SPA ABSI;
ABSI:	NOP 0;
	INVD;
	L 0;
	BTD;
	U M 0.4;
	<>R;
	DEC 0;
	NEGR;
	CALL FC 42;
	CALL FC 42;
	CALL FC 42;
	O M 0.4;
	L 0;
	SE T 42;
	TAR1;
	RRDA;
	UW;
	ZR Z 42;
	L 0;
	CLR;
	SPO ABSJ;
ABSJ:	NOP 0;
END_ORGANIZATION_BLOCK

DATA_BLOCK DB 42
	STRUCT
		VAR : INT;
	END_STRUCT
BEGIN
END_DATA_BLOCK

FUNCTION FC 42 : VOID
BEGIN
	BE;
END_FUNCTION

FUNCTION FC 43 : VOID
BEGIN
	BEA
END_FUNCTION

FUNCTION FC 44 : VOID
BEGIN
	SET;
	BEB;
END_FUNCTION

FUNCTION_BLOCK FB 45
BEGIN
END_FUNCTION_BLOCK

DATA_BLOCK DB 45
	FB 45
BEGIN
END_DATA_BLOCK
